# Repository thorpej/pg68k (continued)

## KiCad design cpu010/design-files/cpu010.kicad_pcb (continued)

Board: 4 copper layers, 401.3 x 203.2 mm, 266 parts (0 on the bottom side), 418 nets.

File cpu010/design-files/cpu010-jlcpcb-bom.csv:

Comment,Designator,Footprint,LCSC Part Number
"Capacitor, ceramic, 100nF, 16V","C202,C203,C204,C205,C301,C302,C303,C304,C305,C306,C307,C308,C309,C310,C311,C312,C313,C314,C315,C316,C317,C318,C319,C320,C321,C322,C323,C324,C333,C334,C401,C402,C403,C404,C405,C406,C407,C412,C413,C414,C415,C416,C417,C418,C419,C501,C502,C503,C504,C505,C506,C507,C508,C509,C510,C511,C512,C513,C514,C515,C516,C517,C518,C519,C520,C521,C522,C601,C602,C603,C604,C605,C606,C607,C608,C701,C702,C703,C704,C705,C706,C707,C709,C710,C712",0805,C520082
"Capacitor, ceramic, 220nF, 16V","C325,C326,C327,C328,C329,C330,C331,C332",0805,C113853
"LED, red","D601,D801,D802",0603,C2286
"Resistor, 10K, 125mW","R101,R102,R103,R206,R207,R208,R209,R211,R212,R603,R606,R607,R613,R701,R702,R703,R704,R705,R706,R707",0805,C17414
"Resistor, 470R, 125mW","R201,R604,R801,R803",0805,C17710
"Resistor, 3K3, 125mW","R204,R205,R709",0805,C26010
"Resistor, 33R, 125mW","R210,R301,R608,R609,R610,R611",0805,C17634
"Resistor, 1K, 125mW","R601,R602,R605,R612",0805,C17513
"Resistor, 4K7, 125mW",R708,0805,C17673
ATF1508AS-7AX100,"U301,U601",TQFP-100(14x14),C1521282
IS61C3216AL-12KLI,U302,SOJ-44,C1351200
AS7C4098A-12JINTR,"U305,U306",SOJ-44,C2064107
CY62158H-45ZSXI,"U502,U503,U504,U505,U508,U509,U510,U511",TSOP-II-44,C2950517
DS3231MZ+,U604,SOIC-8,C722467
L272D,U708,SOIC-16,C2935165
MAX16054AZT+T,U801,SOT-23-6,C79401

## KiCad design cpu030/design-files/cpu030.kicad_pcb

File cpu030/README.md (part):

# Playground 68030 Mk I

The 68030 Mk I is intended as a relatively modest Unix machine.  It
sports the following features:

* 68030 CPU + 68882 FPU running at 25MHz.
* Up to 256MB of 60ns dynamic RAM (as 2x 128MB 72-pin SIMMs).
* 4MB of 10ns static RAM.
* 1MB of flash ROM containing system firmware.
* 2 16550-compatible serial ports (provided by a TL16C2552).
* An ATA disk interface supporting 1 or 2 drives.
* A 10Mb/s twisted pair Ethernet interface (provided by an RTL8019AS).
* An I2C interface (provided by a PCF8584) and real-time clock/calendar
  with battery backup (provided by a DS3231).
* A system timer.
* An expansion port with limited bus master capability.
* An interrupt controller that supports 6 open-drain level-triggered
  interrupt inputs with a global interrupt enable/disable control, plus
  a non-maskable interrupt.
* An ATX power supply with a microcontroller that provides software-
  controlled power-off and system reset.

The system is built around 3 ATF1508AS CPLDs: SYSCTL (system controller),
DRAMCTL (DRAM controller), and ISACTL (ISA bus cycle controller).  All
timing is derived from a 50MHz crystal oscillator that directly clocks
the DRAM controller and is divided down by other controllers to provide
the CPU (and bus) clock, the I2C clock, and the system timer base clock.

The system makes extensive use of the 68030's dynamic bus sizing
mechanism.  This allows the peripheral address space to be densely-
packed and for 16-bit little-endian peripherals (such as ATA disks and
the Ethernet interface) to be handled rationally:

* DRAM and SRAM are 32-bit ports.
* The flash ROM is a 16-bit port (2 chips, "even" and "odd").
* ISA-type peripherals are dynamically 8- or 16-bit ports, depending
  on each individual access width, with some constraints to be
  discussed below.
* The I2C controller is an 8-bit port that natively supports the
  68030 bus protocol.
* The PSU controller is an 8-bit port.

A couple of things that are useful to keep in mind when reading the
rest of this document and reading the schematic:

* D0-D31 are pulled up to Vcc; any data line not driven by a selected
  device will read as 1.
* Several CPU control inputs are pulled up to Vcc and driven with open-drain
  outputs: /DSACKn, /STERM, /BERR, /CI, /CBACK.
* The CPLDs that drive these signals use active-high outputs that are
  inverted by 74ACT05 open-drain inverters; this was done because I had
  trouble with the Atmel fitter crashing when attempting to use the
  open-collector output feature of the ATF1508AS (or even faking it using
  tri-state outputs in the Verilog).  If I can get the tools working
  properly, this may change in a future revision of the board.

## Clocks and reset generation

There are 3 oscillators on the Mk I:

* 50MHz - This clocks the DRAM and is divided by the system controller
  for other clocks, including the CPU clock.
* 20MHz - This is clock source for the 10Mb/s Ethernet interface.
* 1.8432MHz - This is the baud rate clock for the DUART.

Reset generation is handled by a DS1813 reset supervisor.  This handy
little IC has an internal pull-up resistor for /RESET and monitors
the signal as well as Vcc.  If /RESET is pulled low or if Vcc drops
below a threshold voltage (such as in a brown-out condition), then
the DS1813 pulls /RESET low for 150ms.  The DS1813 draws very little
current, typically 30uA, and its power is supplied by the PWR_OK signal
from the ATX power supply.  This ensures that /RESET is asserted until
the power supply is stable.

The system controller is reponsible for dividing the DRAM clock into
other clocks.  It's important for those clocks to be stable and running
when other devices come out of a reset condition.  As such, the counter
used to divide the clock cannot reset with the /RESET signal, meaning
that the value in the counter will be undefined at power-on.  So, the
initial power-on-reset is elongated using an RC circuit on the DS1813's
Vcc pin.  This provides plenty of time for the system controller's
clock divider counter to run and get into a rational state before other
devices begin consuming the clocks.  A reverse-biased diode provides
a fast discharge path for the capacitor when the system is powered off.

## SYSCTL - The system controller

The system controller has 6 major functions:

* A clock divider, providing 25MHz and 6.25MHz clocks dervied from the
  50MHz DRAM clock.
* Top-level address decoding, plus address decoding for the on-board
  peripherals that natively support the 68030 bus protocol.
* Zero-wait-state interface to the SRAM.
* A bus cycle state machine for ROM and PSU controller accesses.
* Bus error generation.
* Miscellaneous logic.

The system controller logic is written in Verilog and synthesized for
the Atmel ATF1508AS-7 CPLD in a TQFP-100 package using Yosys and the
Atmel fitter tool.

### Clock divider

The clock divider is implemented as a 3-bit counter that increments
on the rising edge of the DRAM_CLK input.  The CPU_CLK output is
taken from bit 0 of the counter (thus dividing the input by 2) and
the CLK_6_25 output is taken from bit 2 (thus dividing the output by 8).
You can find the block of code that does this by looking for `ClockDivider`
in [sysctl.v](cpld-files/sysctl.v).

### Address decoding

The address decoder is responsible for decoding the 68030 function code
and address and asserting the appropriate select signal outputs.  The
top-level address map is as follows:

| Address range           | Function                   |
|-------------------------|----------------------------|
| $FFF0.0000 - $FFFF.FFFF | System ROM (1MB)           |
| $FFE0.0000 - $FFEF.FFFF | On-board peripherals (1MB) |
| $FE00.0000 - $FE3F.FFFF | Fast SRAM (4MB)            |
| $8000.0000 - $80FF.FFFF | Expansion port (16MB)      |
| $0000.0000 - $3FFF.FFFF | DRAM (1GB, as 4x256MB)     |

This doesn't quite tell the whole story, though.  The 68k qualifies every
address with a function code on the FC[2..0] bus signals.  The codes are
as follows:

| FC2 | FC1 | FC0 | Address space            |
|-----|-----|-----|--------------------------|
|  0  |  0  |  0  | (Undefined, reserved)    |
|  0  |  0  |  1  | User data space          |
|  0  |  1  |  0  | User program space       |
|  0  |  1  |  1  | (Undefined, reserved)    |
|  1  |  0  |  0  | (Undefined, reserved)    |
|  1  |  0  |  1  | Supervisor data space    |
|  1  |  1  |  0  | Supervisor program space |
|  1  |  1  |  1  | CPU space                |

The system controller decodes these signals and classifies every bus
cycle into two types:

* User data, user program, supervisor data, and supervisor program are
  classified as "Normal".  Normal space is subdivided per the address
  map above.
* CPU space is classified as "CPU".  CPU space is, among other things,
  used for interrupt acknowledgement and co-processor access.

The three undefined functions are not decoded and, since they do not
assert any select outputs, will ultimately generate a bus error.

Addresses are normally qualified with the /AS signal from the CPU.  However,
there is one special case that is needed to achieve zero-wait-state FPU
bus cycles.

There is one additional twist to address decoding: handling of the reset
vector fetch.  Upon reset, the CPU fetches two longwords located at
$0000.0000 (initial stack pointer) and $0000.0004 (reset PC).  Those memory
locations are normally in DRAM.  To handle this situation, the system
controller counts the first 4 bus cycles after a reset and sets an internal
signal indicating that a reset vector fetch is occurring.  The address
decoding logic uses this internal signal to select the ROM rather than DRAM
during these 4 bus cycles.  Why 4?  Because the ROM is a 16-bit port, and
thus 4 bus cycles are required to read the 2 long words.  You can find the
the block of code that does this by looking for `BootState` in
[sysctl.v](cpld-files/sysctl.v).

The actual top-level address decode is performed using a `casex` statement

Parts:
C101: 100µF; CP_EIA-6032-15_Kemet-U_HandSolder; Part T495C107K016ATE200
C102, C113, C122, C123, C131, C132: 100nF; C_0805_2012Metric
C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C124, C125, C126, C127, C128, C129, C130: 220nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C114, C115, C116, C117, C118, C119, C120, C121: 220nF; C_0805_2012Metric
C133, C134: 470µF; CP_Radial_D10.0mm_P5.00mm; Part ESL477M025AH9AA
D101: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H101, H102, H103, H104, H105, H106: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J101: Reset / Power / NMI; PinHeader_2x03_P2.54mm_Vertical
J102: SYSCTL JTAG; PinHeader_2x05_P2.54mm_Vertical
R101, R105, R106, R107, R108: 3K3; R_0805_2012Metric
R102, R103, R104: 10K; R_0805_2012Metric
RN101, RN102, RN103, RN104, RN105: 3K3; R_Array_SIP9
RN106: 3K3; R_Array_SIP7
SW101: Reset; SW_PUSH_6mm
SW102: NMI; SW_PUSH_6mm
U101: MC68030; PGA169
U102: ATF1508AS; TQFP-100_14x14mm_P0.5mm; Part ATF1508AS-7AX100
U103, U109: 74ACT05; SOIC-14_3.9x8.7mm_P1.27mm; Part MC74ACT05DG
U104, U110: DS1813; SOT-23-3; Part DS1813R-10+T&R
U105: SST39SF040 (E); DIP-32_W15.24mm_Socket
U106: SST39SF040 (O); DIP-32_W15.24mm_Socket
U107: MC68882; PGA68
U108: GAL22V10; DIP-24_W7.62mm_Socket
Y101: 50MHz; Oscillator_DIP-8; Part MXO45HS-3C-50M0000

Connections:
+5V: C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.1, C113.1, C114.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.1, C134.1, J102.1, R102.2, R103.2, R105.1, R106.1, R107.1, R108.1, RN101.1 (common), RN102.1 (common), RN103.1 (common), RN104.1 (common), RN105.1 (common), RN106.1 (common), U101.C6 (VCC), U101.D4 (VCC), U101.D10 (VCC), U101.F2 (VCC), U101.F11 (VCC), U101.H3 (VCC), U101.H11 (VCC), U101.K4 (VCC), U101.K10 (VCC), U101.L6 (VCC), U102.3 (VCCio), U102.18 (VCCio), U102.34 (VCCio), U102.39 (VCC), U102.51 (VCCio), U102.66 (VCCio), U102.82 (VCCio), U102.91 (VCC), U103.14 (VCC), U105.31 (PGM), U105.32 (VCC), U106.31 (PGM), U106.32 (VCC), U107.A1 (VCC), U107.B1 (VCC), U107.B8 (VCC), U107.E2 (VCC), U107.E9 (VCC), U107.H8 (VCC), U107.J2 (VCC), U108.24 (VCC), U109.14 (VCC), U110.2 (Vcc), Y101.8 (Vcc); also elsewhere on the board
/SYSCTL_BERR: U102.5 (I/O), U103.5
/SYSCTL_CBACK: U102.6 (I/O), U103.13
/SYSCTL_CI: U102.8 (I/O), U103.9
/SYSCTL_DSACK0: U102.1 (I/O/PD1), U103.1
/SYSCTL_DSACK1: U102.2 (I/O), U103.3
/SYSCTL_STERM: U102.7 (I/O), U103.11
/SYSCTL_TCK: J102.4, R104.1, U102.62 (I/O/TCK)
/SYSCTL_TDI: J102.8, R103.1, U102.4 (I/O/TDI)
/SYSCTL_TDO: J102.6, U102.73 (I/O/TDO)
/SYSCTL_TMS: J102.2, R102.1, U102.15 (I/O/TMS)
/~HALT: R108.2, U101.H2 (/HALT)
/~MMUDIS: R107.2, U101.F13 (/MMUDIS), U101.H12 (/CDIS)
A0: U101.A2 (A0), U102.35 (I/O); also elsewhere on the board
A1: U101.C4 (A1), U102.36 (I/O), U105.12 (A0), U106.12 (A0), U107.K1 (A1); also elsewhere on the board
A2: U101.D13 (A2), U102.37 (I/O), U105.11 (A1), U106.11 (A1), U107.H2 (A2); also elsewhere on the board
A3: U101.D12 (A3), U102.40 (I/O), U105.10 (A2), U106.10 (A2), U107.J1 (A3); also elsewhere on the board
A4: U101.C13 (A4), U102.41 (I/O/PD2), U105.9 (A3), U106.9 (A3), U107.G2 (A4); also elsewhere on the board
A5: U101.C12 (A5), U102.42 (I/O), U105.8 (A4), U106.8 (A4); also elsewhere on the board
A6: U101.D11 (A6), U102.44 (I/O), U105.7 (A5), U106.7 (A5); also elsewhere on the board
A7: U101.B13 (A7), U102.45 (I/O), U105.6 (A6), U106.6 (A6); also elsewhere on the board
A8: U101.B12 (A8), U102.46 (I/O), U105.5 (A7), U106.5 (A7); also elsewhere on the board
A9: U101.C11 (A9), U102.47 (I/O), U105.27 (A8), U106.27 (A8); also elsewhere on the board
A10: U101.A13 (A10), U102.48 (I/O), U105.26 (A9), U106.26 (A9); also elsewhere on the board
A11: U101.C10 (A11), U102.49 (I/O), U105.23 (A10), U106.23 (A10); also elsewhere on the board
A12: U101.B11 (A12), U102.50 (I/O), U105.25 (A11), U106.25 (A11); also elsewhere on the board
A13: U101.A12 (A13), U102.52 (I/O), U105.4 (A12), U106.4 (A12); also elsewhere on the board
A14: U101.B10 (A14), U102.53 (I/O), U105.28 (A13), U106.28 (A13); also elsewhere on the board
A15: U101.A11 (A15), U102.54 (I/O), U105.29 (A14), U106.29 (A14); also elsewhere on the board
A16: U101.B9 (A16), U102.55 (I/O), U105.3 (A15), U106.3 (A15); also elsewhere on the board
A17: U101.A10 (A17), U102.56 (I/O), U105.2 (A16), U106.2 (A16); also elsewhere on the board
A18: U101.C8 (A18), U102.57 (I/O), U105.30 (A17), U106.30 (A17); also elsewhere on the board
A19: U101.A9 (A19), U102.58 (I/O), U105.1 (A18), U106.1 (A18); also elsewhere on the board
A20: U101.B8 (A20), U102.60 (I/O); also elsewhere on the board
A21: U101.A8 (A21), U102.61 (I/O); also elsewhere on the board
A22: U101.B7 (A22), U102.63 (I/O); also elsewhere on the board
A23: U101.A7 (A23), U102.64 (I/O); also elsewhere on the board
A24: U101.A6 (A24), U102.65 (I/O); also elsewhere on the board
A25: U101.B6 (A25), U102.67 (I/O); also elsewhere on the board
A26: U101.A5 (A26), U102.68 (I/O); also elsewhere on the board
A27: U101.B5 (A27), U102.69 (I/O); also elsewhere on the board
A28: U101.A4 (A28), U102.70 (I/O); also elsewhere on the board
A29: U101.B4 (A29), U102.71 (I/O); also elsewhere on the board
A30: U101.A3 (A30), U102.72 (I/O); also elsewhere on the board
A31: U101.B3 (A31), U102.75 (I/O); also elsewhere on the board
ATA_INT: U109.1; also elsewhere on the board
CLK_6_25: U102.84 (I/O); also elsewhere on the board
CPU_CLK: U101.E1 (CLK), U102.83 (I/O), U107.C2 (CLK); also elsewhere on the board
D0: RN102.2 (R1), U101.K13 (D0), U107.A3 (D0); also elsewhere on the board
D1: RN102.3 (R2), U101.K12 (D1), U107.A4 (D1); also elsewhere on the board
D2: RN102.4 (R3), U101.L13 (D2), U107.B5 (D2); also elsewhere on the board
D3: RN102.5 (R4), U101.M13 (D3), U107.A5 (D3); also elsewhere on the board
D4: RN102.6 (R5), U101.L12 (D4), U107.A6 (D4); also elsewhere on the board
D5: RN102.7 (R6), U101.K11 (D5), U107.B6 (D5); also elsewhere on the board
D6: RN102.8 (R7), U101.M12 (D6), U107.A7 (D6); also elsewhere on the board
D7: RN102.9 (R8), U101.L11 (D7), U107.A8 (D7); also elsewhere on the board
D8: RN103.2 (R1), U101.N13 (D8), U107.A9 (D8); also elsewhere on the board
D9: RN103.3 (R2), U101.M11 (D9), U107.C8 (D9); also elsewhere on the board
D10: RN103.4 (R3), U101.L10 (D10), U107.B9 (D10); also elsewhere on the board
D11: RN103.5 (R4), U101.N12 (D11), U107.B10 (D11); also elsewhere on the board
D12: RN103.6 (R5), U101.M10 (D12), U107.D9 (D12); also elsewhere on the board
D13: RN103.7 (R6), U101.N11 (D13), U107.C9 (D13); also elsewhere on the board
D14: RN103.8 (R7), U101.M9 (D14), U107.C10 (D14); also elsewhere on the board
D15: RN103.9 (R8), U101.N10 (D15), U107.D10 (D15); also elsewhere on the board
D16: RN104.2 (R1), U101.N9 (D16), U106.13 (D0), U107.F10 (D16); also elsewhere on the board
D17: RN104.3 (R2), U101.M8 (D17), U106.14 (D1), U107.F9 (D17); also elsewhere on the board
D18: RN104.4 (R3), U101.N8 (D18), U106.15 (D2), U107.G10 (D18); also elsewhere on the board
D19: RN104.5 (R4), U101.N7 (D19), U106.17 (D3), U107.H10 (D19); also elsewhere on the board
D20: RN104.6 (R5), U101.M7 (D20), U106.18 (D4), U107.G9 (D20); also elsewhere on the board
D21: RN104.7 (R6), U101.N6 (D21), U106.19 (D5), U107.J10 (D21); also elsewhere on the board
D22: RN104.8 (R7), U101.M6 (D22), U106.20 (D6), U107.K10 (D22); also elsewhere on the board
D23: RN104.9 (R8), U101.N5 (D23), U106.21 (D7), U107.J9 (D23); also elsewhere on the board
D24: RN105.2 (R1), U101.M5 (D24), U105.13 (D0), U107.K9 (D24), U108.21 (IO8); also elsewhere on the board
D25: RN105.3 (R2), U101.N4 (D25), U105.14 (D1), U107.J7 (D25); also elsewhere on the board
D26: RN105.4 (R3), U101.N3 (D26), U105.15 (D2), U107.K8 (D26); also elsewhere on the board
D27: RN105.5 (R4), U101.M4 (D27), U105.17 (D3), U107.K7 (D27); also elsewhere on the board
D28: RN105.6 (R5), U101.N2 (D28), U105.18 (D4), U107.J6 (D28); also elsewhere on the board
D29: RN105.7 (R6), U101.M3 (D29), U105.19 (D5), U107.K6 (D29); also elsewhere on the board
D30: RN105.8 (R7), U101.L4 (D30), U105.20 (D6), U107.K5 (D30); also elsewhere on the board
D31: RN105.9 (R8), U101.N1 (D31), U105.21 (D7), U107.J5 (D31); also elsewhere on the board
DRAM_CLK: U102.90 (I/OE2/GCLK2), Y101.5 (OUT); also elsewhere on the board
DUART_INT: U109.11; also elsewhere on the board
ETH_INT: U109.13; also elsewhere on the board
FC0: U101.D2 (FC0), U102.76 (I/O); also elsewhere on the board
FC1: U101.C1 (FC1), U102.77 (I/O); also elsewhere on the board
FC2: U101.D1 (FC2), U102.78 (I/O); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, H101.1, H102.1, H103.1, H104.1, H105.1, H106.1, J101.1, J101.3, J101.5, J102.3, J102.5, J102.9, R104.2, SW101.2, SW102.2, U101.C5 (GND), U101.C7 (GND), U101.C9 (GND), U101.E3 (GND), U101.E11 (GND), U101.F3 (GND), U101.G3 (GND), U101.G11 (GND), U101.J3 (GND), U101.J11 (GND), U101.L5 (GND), U101.L7 (GND), U101.L8 (GND), U101.L9 (GND), U102.11 (GND), U102.26 (GND), U102.38 (GND), U102.43 (GND), U102.59 (GND), U102.74 (GND), U102.86 (GND), U102.95 (GND), U103.7 (GND), U104.3 (GND), U105.16 (GND), U106.16 (GND), U107.A2 (GND), U107.A10 (GND), U107.B2 (GND), U107.B3 (GND), U107.B7 (GND)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; also elsewhere on the board
unnamed: C101.1, D101.2 (A), R101.2, U104.2 (Vcc)
unnamed: R105.2, U107.F1 (~SIZE), U107.H3 (A0)
PWR_OK: D101.1 (K), R101.1; also elsewhere on the board
RESET: U102.92 (I/O); also elsewhere on the board
RnW: U101.L3 (R/W), U102.31 (I/O), U107.K2 (R/~W), U108.13 (I12); also elsewhere on the board
SIZ0: U101.L2 (SIZ0), U102.32 (I/O); also elsewhere on the board
SIZ1: U101.K3 (SIZ1), U102.33 (I/O); also elsewhere on the board
TMRINT: U109.9; also elsewhere on the board
~AS: U101.J2 (/AS), U102.87 (I/GCLK1), U107.H1 (~AS); also elsewhere on the board
~AVEC: U101.E2 (/AVEC), U108.18 (IO5)
~CBREQ: U101.K1 (/CBREQ), U102.30 (I/O); also elsewhere on the board
~CPU_BERR: RN101.7 (R6), U101.H1 (/BERR), U103.6, U108.19 (IO6); also elsewhere on the board
~CPU_BGACK: RN101.3 (R2), U101.C3 (/BGACK); also elsewhere on the board
~CPU_BG: RN101.2 (R1), U101.B2 (/BG); also elsewhere on the board
~CPU_BR: R106.2, U101.A1 (/BR); also elsewhere on the board
~CPU_CBACK: RN101.8 (R7), U101.J1 (/CBACK), U103.12; also elsewhere on the board
~CPU_CIIN: RN101.9 (R8), U101.L1 (/CIIN), U103.8; also elsewhere on the board
~CPU_DBEN: U101.M1 (/DBEN); also elsewhere on the board
~CPU_DSACK0: RN101.4 (R3), U101.F1 (/DSACK0), U103.2, U107.J4 (~DSACK0), U108.20 (IO7); also elsewhere on the board
~CPU_DSACK1: RN101.6 (R5), U101.G2 (/DSACK1), U103.4, U107.K4 (~DSACK1); also elsewhere on the board
~CPU_STERM: RN101.5 (R4), U101.G1 (/STERM), U103.10; also elsewhere on the board
~DRAM0SEL: U102.93 (I/O); also elsewhere on the board
~DS: U101.K2 (/DS), U102.88 (I/OE1/Vpp), U107.G1 (~DS), U108.1 (I1/CLK); also elsewhere on the board
~EXPSEL: U102.28 (I/O); also elsewhere on the board
~FPUSEL: U102.81 (I/O), U107.J3 (~CS)
~FRAMSEL: U102.9 (I/O); also elsewhere on the board
~FRAM_BE0: U102.13 (I/O); also elsewhere on the board
~FRAM_BE1: U102.14 (I/O); also elsewhere on the board
~FRAM_BE2: U102.16 (I/O); also elsewhere on the board
~FRAM_BE3: U102.17 (I/O); also elsewhere on the board
~FRAM_RD: U102.10 (I/O); also elsewhere on the board
~FRAM_WR: U102.12 (I/O); also elsewhere on the board
~I2CSEL: U102.98 (I/O); also elsewhere on the board
~IACKSEL: U102.79 (I/O), U108.9 (I9)
~INT1: RN106.2 (R1), U108.2 (I2)
~INT2: RN106.3 (R2), U108.3 (I3); also elsewhere on the board
~INT3: RN106.4 (R3), U108.4 (I4), U109.2; also elsewhere on the board
~INT4: RN106.5 (R4), U108.5 (I5), U109.12; also elsewhere on the board
~INT5: RN106.6 (R5), U108.6 (I6), U109.10; also elsewhere on the board
~INT6: RN106.7 (R6), U108.7 (I7), U109.8; also elsewhere on the board
~INT7: J101.6, SW102.1, U108.8 (I8), U110.1 (~RST)
~INTCSEL: U102.80 (I/O), U108.11 (I11)
~IPL0: U101.H13 (/IPL0), U108.15 (IO2)
~IPL1: U101.G13 (/IPL1), U108.16 (IO3)
~IPL2: U101.G12 (/IPL2), U108.17 (IO4)
~ISASEL: U102.99 (I/O); also elsewhere on the board
~PSUSEL: U102.29 (I/O); also elsewhere on the board
~PWR_BUT: J101.4; also elsewhere on the board
~RESET: J101.2, SW101.1, U101.F12 (/RESET), U102.89 (I/GCLR), U104.1 (~RST), U107.D1 (~RESET), U108.10 (I10); also elsewhere on the board
~ROMSEL: U102.100 (I/O), U105.22 (CE), U105.24 (OE), U106.22 (CE), U106.24 (OE)

Notes on the sheet:
INTC-1
SYSCTL

Parts:
C501, C502, C503: 100nF; C_0805_2012Metric
C504: 470µF; CP_Radial_D10.0mm_P5.00mm; Part ESL477M025AH9AA
D501: ATA Active; LED_D3.0mm
J501: ATA connector; IDC-Header_2x20_P2.54mm_Vertical
J502: 5V CF Power; PinHeader_1x04_P2.54mm_Vertical
R501: 47K; R_0805_2012Metric
R503: 470; R_0805_2012Metric
U501, U502, U503: 74ACT245; SOIC-20W_7.5x12.8mm_P1.27mm; Part 74ACT245SCX

Connections:
+5V: C501.1, C502.1, C503.1, C504.1, J502.1, R503.1, U501.20 (VCC), U502.20 (VCC), U503.20 (VCC); also elsewhere on the board
/IDE interface/ATA_A0: J501.35, U503.4 (A2)
/IDE interface/ATA_A1: J501.33, U503.6 (A4)
/IDE interface/ATA_A2: J501.36, U503.5 (A3)
/IDE interface/ATA_D0: J501.17, U501.2 (A0)
/IDE interface/ATA_D1: J501.15, U501.3 (A1)
/IDE interface/ATA_D2: J501.13, U501.4 (A2)
/IDE interface/ATA_D3: J501.11, U501.5 (A3)
/IDE interface/ATA_D4: J501.9, U501.6 (A4)
/IDE interface/ATA_D5: J501.7, U501.7 (A5)
/IDE interface/ATA_D6: J501.5, U501.8 (A6)
/IDE interface/ATA_D7: J501.3, U501.9 (A7)
/IDE interface/ATA_D8: J501.4, U502.9 (A7)
/IDE interface/ATA_D9: J501.6, U502.8 (A6)
/IDE interface/ATA_D10: J501.8, U502.7 (A5)
/IDE interface/ATA_D11: J501.10, U502.6 (A4)
/IDE interface/ATA_D12: J501.12, U502.5 (A3)
/IDE interface/ATA_D13: J501.14, U502.4 (A2)
/IDE interface/ATA_D14: J501.16, U502.3 (A1)
/IDE interface/ATA_D15: J501.18, U502.2 (A0)
/IDE interface/~ATA_ACT: D501.1 (K), J501.39
/IDE interface/~ATA_CS1FX: J501.37, U503.2 (A0)
/IDE interface/~ATA_CS3FX: J501.38, U503.3 (A1)
/IDE interface/~ATA_IORD: J501.25, U503.8 (A6)
/IDE interface/~ATA_IOWR: J501.23, U503.9 (A7)
/IDE interface/~ATA_RESET: J501.1, U503.7 (A5)
A0: U503.16 (B2); also elsewhere on the board
A1: U503.14 (B4); also elsewhere on the board
A2: U503.15 (B3); also elsewhere on the board
ATA_INT: J501.31, R501.1; also elsewhere on the board
D16: U502.11 (B7); also elsewhere on the board
D17: U502.12 (B6); also elsewhere on the board
D18: U502.13 (B5); also elsewhere on the board
D19: U502.14 (B4); also elsewhere on the board
D20: U502.15 (B3); also elsewhere on the board
D21: U502.16 (B2); also elsewhere on the board
D22: U502.17 (B1); also elsewhere on the board
D23: U502.18 (B0); also elsewhere on the board
D24: U501.18 (B0); also elsewhere on the board
D25: U501.17 (B1); also elsewhere on the board
D26: U501.16 (B2); also elsewhere on the board
D27: U501.15 (B3); also elsewhere on the board
D28: U501.14 (B4); also elsewhere on the board
D29: U501.13 (B5); also elsewhere on the board
D30: U501.12 (B6); also elsewhere on the board
D31: U501.11 (B7); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, J501.2, J501.19, J501.22, J501.24, J501.26, J501.30, J501.40, J502.2, J502.3, R501.2, U501.10 (GND), U502.10 (GND), U503.1 (A->B), U503.10 (GND), U503.19 (CE); also elsewhere on the board
ISA_RDY: J501.27; also elsewhere on the board
unnamed: D501.2 (A), R503.2
RnW: U501.1 (A->B), U502.1 (A->B); also elsewhere on the board
~ATAAUXSEL: U503.17 (B1); also elsewhere on the board
~ATABEN: U501.19 (CE), U502.19 (CE); also elsewhere on the board
~ATASEL: U503.18 (B0); also elsewhere on the board
~ISA_IO16: J501.32; also elsewhere on the board
~ISA_IORD: U503.12 (B6); also elsewhere on the board
~ISA_IOWR: U503.11 (B7); also elsewhere on the board
~RESET: U503.13 (B5); also elsewhere on the board
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