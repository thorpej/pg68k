# Repository thorpej/pg68k (continued)

## KiCad design cpu030/design-files/cpu030.kicad_pcb (continued)

Parts:
C701, C702, C703, C704, C705, C706, C707, C708, C709, C710, C711: 100nF; C_0805_2012Metric
C712, C713: 10nF; C_0805_2012Metric
J701: RJ45_Amphenol_RJMG1BD3B8K1ANR
R701, R702: 10K; R_0805_2012Metric
R703, R704: 470; R_0805_2012Metric
R705, R706: 49.9; R_0805_2012Metric
R707, R708: 10; R_0805_2012Metric
R709: 22; R_0805_2012Metric
U701: RTL8019AS; PQFP-100_14x20mm_P0.65mm
U702: AT93C46D-PU; DIP-8_W7.62mm_Socket
Y701: 20MHz; Oscillator_DIP-8; Part MXO45HS-3C-20M0000

Connections:
+5V: C701.1, C702.1, C703.1, C704.1, C705.1, C706.1, C707.1, C708.1, R701.1, R702.1, R703.1, R704.1, U701.6 (VCC), U701.17 (VCC), U701.47 (VCC), U701.57 (VCC), U701.70 (VCC), U701.89 (VCC), U702.6 (ORG), U702.8 (VCC), Y701.8 (Vcc); also elsewhere on the board
/Ethernet/ETH_CLK: R709.1, U701.50 (X1)
/Ethernet/ETH_EECS: U701.76 (EECS), U702.1 (CS)
/Ethernet/ETH_EEDI: U701.78 (BD6/IRQS0/EEDI), U702.3 (DI)
/Ethernet/ETH_EEDO: U701.77 (BD7/PL1/EEDO), U702.4 (DO)
/Ethernet/ETH_EESK: U701.79 (BD5/IRQS1/EESK), U702.2 (SCLK)
/Ethernet/ETH_RD+: J701.R3 (RD+), R706.1, U701.59 (TPIN+)
/Ethernet/ETH_RD-: J701.R6 (RD-), R705.1, U701.58 (TPIN-)
/Ethernet/ETH_TD+: J701.R1 (TD+), R707.2
/Ethernet/ETH_TD-: J701.R2 (TD-), R708.1
/Ethernet/~ETH_GLED: J701.L3, U701.61 (LED0/LED_COL/LED_LINK)
/Ethernet/~ETH_YLED: J701.L2, U701.62 (LED1/LED_RX/LED_CRS)
A0: U701.5 (SA0); also elsewhere on the board
A1: U701.7 (SA1); also elsewhere on the board
A2: U701.8 (SA2); also elsewhere on the board
A3: U701.9 (SA3); also elsewhere on the board
A4: U701.10 (SA4); also elsewhere on the board
D16: U701.95 (SD8); also elsewhere on the board
D17: U701.94 (SD9); also elsewhere on the board
D18: U701.93 (SD10); also elsewhere on the board
D19: U701.92 (SD11); also elsewhere on the board
D20: U701.91 (SD12); also elsewhere on the board
D21: U701.90 (SD13); also elsewhere on the board
D22: U701.88 (SD14); also elsewhere on the board
D23: U701.87 (SD15); also elsewhere on the board
D24: U701.36 (SD0); also elsewhere on the board
D25: U701.37 (SD1); also elsewhere on the board
D26: U701.38 (SD2); also elsewhere on the board
D27: U701.39 (SD3); also elsewhere on the board
D28: U701.40 (SD4); also elsewhere on the board
D29: U701.41 (SD5); also elsewhere on the board
D30: U701.42 (SD6); also elsewhere on the board
D31: U701.43 (SD7); also elsewhere on the board
ETH_INT: U701.4 (INT0/IRQ2/9); also elsewhere on the board
GND: C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C711.2, C712.2, C713.2, J701.R8, J701.SH, U701.11 (SA5), U701.12 (SA6), U701.13 (SA7), U701.14 (GND), U701.18 (SA10), U701.19 (SA11), U701.20 (SA12), U701.21 (SA13), U701.22 (SA14), U701.23 (SA15), U701.24 (SA16), U701.25 (SA17), U701.26 (SA18), U701.27 (SA19), U701.28 (GND), U701.44 (GND), U701.52 (GND), U701.64 (AUI), U701.83 (GND), U701.86 (GND), U702.5 (GND), Y701.4 (GND); also elsewhere on the board
ISA_RDY: U701.35 (IOCHRDY); also elsewhere on the board
unnamed: C711.1, R705.2, R706.2
unnamed: J701.L1, R703.2
unnamed: J701.L4, R704.2
unnamed: C710.1, J701.R5 (RCT)
unnamed: C709.1, J701.R4 (TCT)
unnamed: R702.2, U701.65 (JP)
unnamed: R701.2, U701.15 (SA8), U701.16 (SA9), U701.31 (~SMEMRB), U701.32 (~SMEMWB)
unnamed: C712.1, R707.1, U701.45 (TPOUT+)
unnamed: C713.1, R708.2, U701.46 (TPOUT-)
unnamed: R709.2, Y701.5 (OUT)
RESET: U701.33 (RSTDRV); also elsewhere on the board
~ETHSEL: U701.34 (AEN); also elsewhere on the board
~ISA_IO16: U701.96 (~IOCS16B/SLOT16); also elsewhere on the board
~ISA_IORD: U701.29 (~IORB); also elsewhere on the board
~ISA_IOWR: U701.30 (~IOWB); also elsewhere on the board

Notes on the sheet:
The chip is wired for "jumper mode", and the IRQSx and IOSx connections select INT0 and I/O address 0x300. ISACTL only asserts ~{ETHSEL} for 0x300, and the address lines are hard-wired for it. Only A[4..0] need be routed on the board.

Parts:
C201, C202, C203, C204, C205, C206, C207, C208, C210, C211, C212, C213, C214, C215, C216, C217, C218, C219, C220, C221, C222, C223, C224, C225: 220nF; C_0805_2012Metric
C209: 100nF; C_0805_2012Metric
J201: DRAM0SZ; PinHeader_1x02_P2.54mm_Vertical
J202: DRAM0 JTAG; PinHeader_2x05_P2.54mm_Vertical
R201, R202, R203, R204, R205, R206, R207, R208, R209, R210, R211, R212: 10K; R_0805_2012Metric
U201: ATF1508AS; TQFP-100_14x14mm_P0.5mm; Part ATF1508AS-7AX100
U202: CY7C1061GE (U16); TSOP-II-54_22.2x10.16mm_P0.8mm
U203: CY7C1061GE (L16); TSOP-II-54_22.2x10.16mm_P0.8mm
U204: SIMM72-0A; SIMM-72
U205: SIMM72-0B; SIMM-72
U206: 74ACT05; SOIC-14_3.9x8.7mm_P1.27mm; Part MC74ACT05DG

Connections:
+5V: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, C220.1, C221.1, C222.1, C223.1, C224.1, C225.1, J202.1, R201.1, R202.2, R203.2, R205.1, R206.1, R207.1, R208.1, R209.1, R210.1, R211.1, R212.1, U201.3 (VCCio), U201.18 (VCCio), U201.34 (VCCio), U201.39 (VCC), U201.51 (VCCio), U201.66 (VCCio), U201.82 (VCCio), U201.91 (VCC), U202.2 (Vcc), U202.14 (Vcc), U202.16 (CE2), U202.23 (Vcc), U202.29 (Vcc), U202.50 (Vcc), U203.2 (Vcc), U203.14 (Vcc), U203.16 (CE2), U203.23 (Vcc), U203.29 (Vcc), U203.50 (Vcc), U204.10 (VCC), U204.30 (VCC), U204.59 (VCC), U205.10 (VCC), U205.30 (VCC), U205.59 (VCC), U206.14 (VCC); also elsewhere on the board
/FRAM + DRAM0/DRAM0A_PD1: R205.2, U201.80 (I/O), U204.67 (PD1)
/FRAM + DRAM0/DRAM0A_PD2: R206.2, U201.81 (I/O), U204.68 (PD2)
/FRAM + DRAM0/DRAM0A_PD3: R207.2, U201.83 (I/O), U204.69 (PD3)
/FRAM + DRAM0/DRAM0A_PD4: R208.2, U201.84 (I/O), U204.70 (PD4)
/FRAM + DRAM0/DRAM0B_PD1: R209.2, U201.92 (I/O), U205.67 (PD1)
/FRAM + DRAM0/DRAM0B_PD2: R210.2, U201.93 (I/O), U205.68 (PD2)
/FRAM + DRAM0/DRAM0B_PD3: R211.2, U201.94 (I/O), U205.69 (PD3)
/FRAM + DRAM0/DRAM0B_PD4: R212.2, U201.96 (I/O), U205.70 (PD4)
/FRAM + DRAM0/DRAM0_A0: U201.46 (I/O), U204.12 (A0), U205.12 (A0)
/FRAM + DRAM0/DRAM0_A1: U201.47 (I/O), U204.13 (A1), U205.13 (A1)
/FRAM + DRAM0/DRAM0_A2: U201.48 (I/O), U204.14 (A2), U205.14 (A2)
/FRAM + DRAM0/DRAM0_A3: U201.49 (I/O), U204.15 (A3), U205.15 (A3)
/FRAM + DRAM0/DRAM0_A4: U201.50 (I/O), U204.16 (A4), U205.16 (A4)
/FRAM + DRAM0/DRAM0_A5: U201.52 (I/O), U204.17 (A5), U205.17 (A5)
/FRAM + DRAM0/DRAM0_A6: U201.53 (I/O), U204.18 (A6), U205.18 (A6)
/FRAM + DRAM0/DRAM0_A7: U201.54 (I/O), U204.28 (A7), U205.28 (A7)
/FRAM + DRAM0/DRAM0_A8: U201.55 (I/O), U204.31 (A8), U205.31 (A8)
/FRAM + DRAM0/DRAM0_A9: U201.56 (I/O), U204.32 (A9), U205.32 (A9)
/FRAM + DRAM0/DRAM0_A10: U201.57 (I/O), U204.19 (A10), U205.19 (A10)
/FRAM + DRAM0/DRAM0_A11: U201.58 (I/O), U204.29 (A11), U205.29 (A11)
/FRAM + DRAM0/DRAM0_BERR: U201.100 (I/O), U206.5
/FRAM + DRAM0/DRAM0_CBACK: U201.98 (I/O), U206.13
/FRAM + DRAM0/DRAM0_DSACK0: U201.1 (I/O/PD1), U206.1
/FRAM + DRAM0/DRAM0_DSACK1: U201.2 (I/O), U206.3
/FRAM + DRAM0/DRAM0_STERM: U201.99 (I/O), U206.11
/FRAM + DRAM0/DRAM0_TCK: J202.4, R204.1, U201.62 (I/O/TCK)
/FRAM + DRAM0/DRAM0_TDI: J202.8, R203.1, U201.4 (I/O/TDI)
/FRAM + DRAM0/DRAM0_TDO: J202.6, U201.73 (I/O/TDO)
/FRAM + DRAM0/DRAM0_TMS: J202.2, R202.1, U201.15 (I/O/TMS)
/FRAM + DRAM0/~DRAM0A_CAS0: U201.65 (I/O), U204.40 (/CAS0)
/FRAM + DRAM0/~DRAM0A_CAS1: U201.67 (I/O), U204.43 (/CAS1)
/FRAM + DRAM0/~DRAM0A_CAS2: U201.68 (I/O), U204.41 (/CAS2)
/FRAM + DRAM0/~DRAM0A_CAS3: U201.69 (I/O), U204.42 (/CAS3)
/FRAM + DRAM0/~DRAM0A_RAS0: U201.60 (I/O), U204.44 (/RAS0)
/FRAM + DRAM0/~DRAM0A_RAS1: U201.61 (I/O), U204.34 (/RAS2)
/FRAM + DRAM0/~DRAM0A_RAS2: U201.63 (I/O), U204.45 (/RAS1)
/FRAM + DRAM0/~DRAM0A_RAS3: U201.64 (I/O), U204.33 (/RAS3)
/FRAM + DRAM0/~DRAM0B_CAS0: U201.76 (I/O), U205.40 (/CAS0)
/FRAM + DRAM0/~DRAM0B_CAS1: U201.77 (I/O), U205.43 (/CAS1)
/FRAM + DRAM0/~DRAM0B_CAS2: U201.78 (I/O), U205.41 (/CAS2)
/FRAM + DRAM0/~DRAM0B_CAS3: U201.79 (I/O), U205.42 (/CAS3)
/FRAM + DRAM0/~DRAM0B_RAS0: U201.70 (I/O), U205.44 (/RAS0)
/FRAM + DRAM0/~DRAM0B_RAS1: U201.71 (I/O), U205.34 (/RAS2)
/FRAM + DRAM0/~DRAM0B_RAS2: U201.72 (I/O), U205.45 (/RAS1)
/FRAM + DRAM0/~DRAM0B_RAS3: U201.75 (I/O), U205.33 (/RAS3)
/FRAM + DRAM0/~DRAM0_WR: U201.45 (I/O), U204.47 (/WE), U205.47 (/WE)
A0: U201.8 (I/O); also elsewhere on the board
A1: U201.9 (I/O); also elsewhere on the board
A2: U201.10 (I/O), U202.11 (A0), U203.11 (A0); also elsewhere on the board
A3: U201.12 (I/O), U202.10 (A1), U203.10 (A1); also elsewhere on the board
A4: U201.13 (I/O), U202.9 (A2), U203.9 (A2); also elsewhere on the board
A5: U201.14 (I/O), U202.8 (A3), U203.8 (A3); also elsewhere on the board
A6: U201.16 (I/O), U202.7 (A4), U203.7 (A4); also elsewhere on the board
A7: U201.17 (I/O), U202.48 (A5), U203.48 (A5); also elsewhere on the board
A8: U201.19 (I/O), U202.47 (A6), U203.47 (A6); also elsewhere on the board
A9: U201.20 (I/O), U202.46 (A7), U203.46 (A7); also elsewhere on the board
A10: U201.21 (I/O), U202.45 (A8), U203.45 (A8); also elsewhere on the board
A11: U201.22 (I/O), U202.44 (A9), U203.44 (A9); also elsewhere on the board
A12: U201.23 (I/O), U202.38 (A10), U203.38 (A10); also elsewhere on the board
A13: U201.24 (I/O), U202.37 (A11), U203.37 (A11); also elsewhere on the board
A14: U201.25 (I/O), U202.36 (A12), U203.36 (A12); also elsewhere on the board
A15: U201.27 (I/O), U202.35 (A13), U203.35 (A13); also elsewhere on the board
A16: U201.28 (I/O), U202.34 (A14), U203.34 (A14); also elsewhere on the board
A17: U201.29 (I/O), U202.21 (A15), U203.21 (A15); also elsewhere on the board
A18: U201.30 (I/O), U202.20 (A16), U203.20 (A16); also elsewhere on the board
A19: U201.31 (I/O), U202.19 (A17), U203.19 (A17); also elsewhere on the board
A20: U201.32 (I/O), U202.18 (A18), U203.18 (A18); also elsewhere on the board
A21: U201.33 (I/O), U202.17 (A19), U203.17 (A19); also elsewhere on the board
A22: U201.35 (I/O); also elsewhere on the board
A23: U201.36 (I/O); also elsewhere on the board
A24: U201.37 (I/O); also elsewhere on the board
A25: U201.40 (I/O); also elsewhere on the board
A26: U201.41 (I/O/PD2); also elsewhere on the board
A27: U201.42 (I/O); also elsewhere on the board
D0: U203.22 (D0), U204.2 (D0), U205.2 (D0); also elsewhere on the board
D1: U203.24 (D1), U204.4 (D1), U205.4 (D1); also elsewhere on the board
D2: U203.25 (D2), U204.6 (D2), U205.6 (D2); also elsewhere on the board
D3: U203.27 (D3), U204.8 (D3), U205.8 (D3); also elsewhere on the board
D4: U203.28 (D4), U204.20 (D4), U205.20 (D4); also elsewhere on the board
D5: U203.30 (D5), U204.22 (D5), U205.22 (D5); also elsewhere on the board
D6: U203.31 (D6), U204.24 (D6), U205.24 (D6); also elsewhere on the board
D7: U203.33 (D7), U204.26 (D7), U205.26 (D7); also elsewhere on the board
D8: U203.49 (D8), U204.49 (D8), U205.49 (D8); also elsewhere on the board
D9: U203.51 (D9), U204.51 (D9), U205.51 (D9); also elsewhere on the board
D10: U203.52 (D10), U204.53 (D10), U205.53 (D10); also elsewhere on the board
D11: U203.54 (D11), U204.55 (D11), U205.55 (D11); also elsewhere on the board
D12: U203.1 (D12), U204.57 (D12), U205.57 (D12); also elsewhere on the board
D13: U203.3 (D13), U204.61 (D13), U205.61 (D13); also elsewhere on the board
D14: U203.4 (D14), U204.63 (D14), U205.63 (D14); also elsewhere on the board
D15: U203.6 (D15), U204.65 (D15), U205.65 (D15); also elsewhere on the board
D16: U202.22 (D0), U204.3 (D16), U205.3 (D16); also elsewhere on the board
D17: U202.24 (D1), U204.5 (D17), U205.5 (D17); also elsewhere on the board
D18: U202.25 (D2), U204.7 (D18), U205.7 (D18); also elsewhere on the board
D19: U202.27 (D3), U204.9 (D19), U205.9 (D19); also elsewhere on the board
D20: U202.28 (D4), U204.21 (D20), U205.21 (D20); also elsewhere on the board
D21: U202.30 (D5), U204.23 (D21), U205.23 (D21); also elsewhere on the board
D22: U202.31 (D6), U204.25 (D22), U205.25 (D22); also elsewhere on the board
D23: U202.33 (D7), U204.27 (D23), U205.27 (D23); also elsewhere on the board
D24: U202.49 (D8), U204.50 (D24), U205.50 (D24); also elsewhere on the board
D25: U202.51 (D9), U204.52 (D25), U205.52 (D25); also elsewhere on the board
D26: U202.52 (D10), U204.54 (D26), U205.54 (D26); also elsewhere on the board
D27: U202.54 (D11), U204.56 (D27), U205.56 (D27); also elsewhere on the board
D28: U202.1 (D12), U204.58 (D28), U205.58 (D28); also elsewhere on the board
D29: U202.3 (D13), U204.60 (D29), U205.60 (D29); also elsewhere on the board
D30: U202.4 (D14), U204.62 (D30), U205.62 (D30); also elsewhere on the board
D31: U202.6 (D15), U204.64 (D31), U205.64 (D31); also elsewhere on the board
DRAM_CLK: U201.90 (I/OE2/GCLK2); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, J201.2, J202.3, J202.5, J202.9, R204.2, U201.11 (GND), U201.26 (GND), U201.38 (GND), U201.43 (GND), U201.59 (GND), U201.74 (GND), U201.86 (GND), U201.95 (GND), U202.5 (Vss), U202.26 (Vss), U202.32 (Vss), U202.41 (Vss), U202.53 (Vss), U203.5 (Vss), U203.26 (Vss), U203.32 (Vss), U203.41 (Vss), U203.53 (Vss), U204.1 (GND), U204.39 (GND), U204.72 (GND), U205.1 (GND), U205.39 (GND), U205.72 (GND), U206.7 (GND), U206.9; also elsewhere on the board
unnamed: J201.1, R201.2, U201.85 (I/O/GCLK3)
RnW: U201.5 (I/O); also elsewhere on the board
SIZ0: U201.6 (I/O); also elsewhere on the board
SIZ1: U201.7 (I/O); also elsewhere on the board
~AS: U201.87 (I/GCLK1); also elsewhere on the board
~CBREQ: U201.97 (I/O); also elsewhere on the board
~CPU_BERR: U206.6; also elsewhere on the board
~CPU_CBACK: U206.12; also elsewhere on the board
~CPU_DSACK0: U206.2; also elsewhere on the board
~CPU_DSACK1: U206.4; also elsewhere on the board
~CPU_STERM: U206.10; also elsewhere on the board
~DRAM0SEL: U201.88 (I/OE1/Vpp); also elsewhere on the board
~FRAMSEL: U202.13 (~CE1), U203.13 (~CE1); also elsewhere on the board
~FRAM_BE0: U203.39 (~BLE); also elsewhere on the board
~FRAM_BE1: U203.12 (~BHE); also elsewhere on the board
~FRAM_BE2: U202.39 (~BLE); also elsewhere on the board
~FRAM_BE3: U202.12 (~BHE); also elsewhere on the board
~FRAM_RD: U202.42 (~OE), U203.42 (~OE); also elsewhere on the board
~FRAM_WR: U202.15 (~WE), U203.15 (~WE); also elsewhere on the board
~RESET: U201.89 (I/GCLR); also elsewhere on the board

Notes on the sheet:
DRAMCTL

Parts:
C401: 100nF; C_0805_2012Metric
C402, C403, C404, C405, C406, C407, C408, C409: 220nF; C_0805_2012Metric
J401: ISACTL JTAG; PinHeader_2x05_P2.54mm_Vertical
R401, R402, R403: 10K; R_0805_2012Metric
R404, R405: 3K3; R_0805_2012Metric
U401: ATF1508AS; TQFP-100_14x14mm_P0.5mm; Part ATF1508AS-7AX100
U402: 74ACT05; SOIC-14_3.9x8.7mm_P1.27mm; Part MC74ACT05DG

Connections:
+5V: C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, J401.1, R401.2, R402.2, R404.1, R405.1, U401.3 (VCCio), U401.18 (VCCio), U401.34 (VCCio), U401.39 (VCC), U401.51 (VCCio), U401.66 (VCCio), U401.82 (VCCio), U401.91 (VCC), U402.14 (VCC); also elsewhere on the board
/ISA bus interface/ISACTL_BERR: U401.100 (I/O), U402.5
/ISA bus interface/ISACTL_DSACK0: U401.1 (I/O/PD1), U402.1
/ISA bus interface/ISACTL_DSACK1: U401.2 (I/O), U402.3
/ISA bus interface/ISACTL_TCK: J401.4, R403.1, U401.62 (I/O/TCK)
/ISA bus interface/ISACTL_TDI: J401.8, R402.1, U401.4 (I/O/TDI)
/ISA bus interface/ISACTL_TDO: J401.6, U401.73 (I/O/TDO)
/ISA bus interface/ISACTL_TMS: J401.2, R401.1, U401.15 (I/O/TMS)
A0: U401.8 (I/O); also elsewhere on the board
A1: U401.9 (I/O); also elsewhere on the board
A2: U401.10 (I/O); also elsewhere on the board
A3: U401.12 (I/O); also elsewhere on the board
A4: U401.13 (I/O); also elsewhere on the board
A5: U401.14 (I/O); also elsewhere on the board
A6: U401.16 (I/O); also elsewhere on the board
A7: U401.17 (I/O); also elsewhere on the board
A8: U401.19 (I/O); also elsewhere on the board
A9: U401.20 (I/O); also elsewhere on the board
CPU_CLK: U401.90 (I/OE2/GCLK2); also elsewhere on the board
D24: U401.21 (I/O); also elsewhere on the board
D25: U401.22 (I/O); also elsewhere on the board
D26: U401.23 (I/O); also elsewhere on the board
D27: U401.24 (I/O); also elsewhere on the board
D28: U401.25 (I/O); also elsewhere on the board
D29: U401.27 (I/O); also elsewhere on the board
D30: U401.28 (I/O); also elsewhere on the board
D31: U401.29 (I/O); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, J401.3, J401.5, J401.9, R403.2, U401.11 (GND), U401.26 (GND), U401.38 (GND), U401.43 (GND), U401.59 (GND), U401.74 (GND), U401.86 (GND), U401.95 (GND), U402.7 (GND), U402.9, U402.11, U402.13; also elsewhere on the board
ISA_RDY: R404.2, U401.84 (I/O); also elsewhere on the board
RnW: U401.5 (I/O); also elsewhere on the board
SIZ0: U401.6 (I/O); also elsewhere on the board
SIZ1: U401.7 (I/O); also elsewhere on the board
TMRINT: U401.50 (I/O); also elsewhere on the board
~AS: U401.87 (I/GCLK1); also elsewhere on the board
~ATAAUXSEL: U401.98 (I/O); also elsewhere on the board
~ATABEN: U401.99 (I/O); also elsewhere on the board
~ATASEL: U401.97 (I/O); also elsewhere on the board
~CPU_BERR: U402.6; also elsewhere on the board
~CPU_DSACK0: U402.2; also elsewhere on the board
~CPU_DSACK1: U402.4; also elsewhere on the board
~DS: U401.88 (I/OE1/Vpp); also elsewhere on the board
~DUARTSEL: U401.71 (I/O); also elsewhere on the board
~ETHSEL: U401.75 (I/O); also elsewhere on the board
~ISASEL: U401.85 (I/O/GCLK3); also elsewhere on the board
~ISA_IO16: R405.2, U401.83 (I/O); also elsewhere on the board
~ISA_IORD: U401.80 (I/O); also elsewhere on the board
~ISA_IOWR: U401.81 (I/O); also elsewhere on the board
~RESET: U401.89 (I/GCLR); also elsewhere on the board

Notes on the sheet:
ISACTL

Parts:
C301, C302, C303, C304: 100nF; C_0805_2012Metric
J301: UART1 FTDI; PinHeader_1x06_P2.54mm_Horizontal
J302: UART0 FTDI; PinHeader_1x06_P2.54mm_Horizontal
J303: UART0; IDC-Header_2x05_P2.54mm_Vertical
J304: UART1; IDC-Header_2x05_P2.54mm_Vertical
RN301: 3K3; R_Array_SIP9
U301: TL16C2552; PLCC-44_THT-Socket
U302: 74ACHT32; SOIC-14_3.9x8.7mm_P1.27mm
Y301: 1.8432MHz; Oscillator_DIP-8; Part MXO45HST-3C-1M8432

Connections:
+5V: C301.1, C302.1, C303.1, C304.1, J303.10, J304.10, RN301.1 (common), U301.33 (VCC), U301.44 (VCC), U302.14 (VCC), Y301.8 (Vcc); also elsewhere on the board
/DUART/DUARTA_RXD: J302.4, J303.2, U301.39 (RXA)
/DUART/DUARTA_TXD: J302.5, J303.3, U301.38 (TXA)
/DUART/DUARTB_RXD: J301.4, J304.2, U301.25 (RXB)
/DUART/DUARTB_TXD: J301.5, J304.3, U301.26 (TXB)
/DUART/~DUARTA_CD: J303.1, RN301.3 (R2), U301.42 (~CDA)
/DUART/~DUARTA_CTS: J302.6, J303.8, RN301.5 (R4), U301.40 (~CTSA)
/DUART/~DUARTA_DSR: J303.6, RN301.4 (R3), U301.41 (~DSRA)
/DUART/~DUARTA_DTR: J303.4, U301.37 (~DTRA)
/DUART/~DUARTA_RI: J303.9, RN301.2 (R1), U301.43 (~RIA)
/DUART/~DUARTA_RTS: J302.2, J303.7, U301.36 (~RTSA)
/DUART/~DUARTB_CD: J304.1, RN301.7 (R6), U301.30 (~CDB)
/DUART/~DUARTB_CTS: J301.6, J304.8, RN301.9 (R8), U301.28 (~CTSB)
/DUART/~DUARTB_DSR: J304.6, RN301.8 (R7), U301.29 (~DSRB)
/DUART/~DUARTB_DTR: J304.4, U301.27 (~DTRB)
/DUART/~DUARTB_RI: J304.9, RN301.6 (R5), U301.31 (~RIB)
/DUART/~DUARTB_RTS: J301.2, J304.7, U301.23 (~RTSB)
A0: U301.10 (A0); also elsewhere on the board
A1: U301.14 (A1); also elsewhere on the board
A2: U301.15 (A2); also elsewhere on the board
A8: U301.16 (CHSEL); also elsewhere on the board
D24: U301.2 (D0); also elsewhere on the board
D25: U301.3 (D1); also elsewhere on the board
D26: U301.4 (D2); also elsewhere on the board
D27: U301.5 (D3); also elsewhere on the board
D28: U301.6 (D4); also elsewhere on the board
D29: U301.7 (D5); also elsewhere on the board
D30: U301.8 (D6); also elsewhere on the board
D31: U301.9 (D7); also elsewhere on the board
DUART_INT: U302.3; also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, J301.1, J302.1, J303.5, J304.5, U301.12 (GND), U301.22 (GND), U302.4, U302.5, U302.7 (GND), U302.9, U302.10, U302.12, U302.13, Y301.4 (GND); also elsewhere on the board
unnamed: U301.34 (INTA), U302.1
unnamed: U301.17 (INTB), U302.2
unnamed: U301.11 (XIN), Y301.5 (OUT)
RESET: U301.21 (RESET); also elsewhere on the board
~DUARTSEL: U301.18 (~CS); also elsewhere on the board
~ISA_IORD: U301.24 (~IOR); also elsewhere on the board
~ISA_IOWR: U301.20 (~IOW); also elsewhere on the board

Notes on the sheet:
IDC 10 connectors are pinned the same as RS232 DB9, with +5V being provided on pin 10. This allows for a remote board with RS232 line drivers to be added. Note: Only connect one kind of external interface to a port at any given time.
FTDI connector: 1=GND 2=CTS 3=Vcc 4=TxD 5=RxD 6=RTS Both ports configured as NULL modem.
Note: A8=0 selects channel B.
