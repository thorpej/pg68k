File: cpu010/design-files/cpu010-control.kicad_sch (KiCad schematic)
At the start: 34 parts, among them SW401 SW_DIP_x08, SW402 SW_DIP_x08, U401 DA04-11SURKWA, U402 74HCT273, U403 74HCT273, U404 GAL22V10, U405 74HC245, U406 74HC245, U407 74HCT273, U408 74HC245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

Commit message: More (NQ)VME tweaks.  Add JTAG chain.
Connections:
- net TMS: now reaches U409.13 (I/O/TMS)
- net ~{VMEBERR}: now reaches U409.24 (I/O)
- net TCK: now reaches U409.32 (I/O/TCK)
- net TDO: now reaches U409.38 (I/O/TDO)
- net BERR_TDI: now reaches U409.7 (I/O/TDI)
- no-connect marks 17 -> 16
Changed lines of the file:
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@@
 		(at 238.76 186.69)
 	)
-	(no_connect
-		(at 238.76 189.23)
-	)
 	(wire
 		(pts
@@
 	(wire
 		(pts
+			(xy 238.76 158.75) (xy 246.38 158.75)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 134.62 80.01) (xy 139.7 80.01)
 		)
@@
 	(wire
 		(pts
+			(xy 243.84 171.45) (xy 238.76 171.45)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 275.59 49.53) (xy 285.75 49.53)
 		)
@@
 	(wire
 		(pts
+			(xy 190.5 171.45) (xy 208.28 171.45)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 252.73 39.37) (xy 265.43 39.37)
 		)
@@
 	(wire
 		(pts
+			(xy 186.69 158.75) (xy 208.28 158.75)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 134.62 87.63) (xy 143.51 87.63)
 		)
@@
 	(wire
 		(pts
+			(xy 246.38 162.56) (xy 250.19 162.56)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 194.31 82.55) (xy 200.66 82.55)
 		)
@@
 	(wire
 		(pts
+			(xy 246.38 158.75) (xy 246.38 162.56)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 46.99 242.57) (xy 58.42 242.57)
 		)
@@
 		)
 	)
+	(global_label "TCK"
+		(shape input)
+		(at 243.84 171.45 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 250.3328 171.45 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "D8"
 		(shape input)
@@
 		)
 	)
+	(global_label "~{VMEBERR}"
+		(shape input)
+		(at 238.76 189.23 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 250.3932 189.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "~{RESET}"
 		(shape input)
@@
 		)
 	)
+	(global_label "TDO"
+		(shape output)
+		(at 250.19 162.56 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 256.7433 162.56 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "D7"
 		(shape input)
@@
 		)
 	)
+	(global_label "TMS"
+		(shape input)
+		(at 190.5 171.45 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 183.8863 171.45 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "VA3"
 		(shape input)
@@
 			(effects
 				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
+	(global_label "BERR_TDI"
+		(shape input)
+		(at 186.69 158.75 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 174.9358 158.75 0)
+			(effects
+				(font

Commit message: Clock generation is now done in the MMU, and we clock the MMU at 40MHz.
Connections:
- net CLK10 renamed CPU_CLK
Changed lines of the file:
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@@
 		)
 	)
-	(global_label "CLK10"
+	(global_label "CPU_CLK"
 		(shape input)
 		(at 199.39 146.05 180)
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 190.4177 146.05 0)
+			(at 187.9986 146.05 0)
 			(effects
 				(font

Commit message: MMU now has Bus Error Register integrated.
Connections:
- net INT_EN: now reaches U407.5 (Q1), U408.17 (B1)
- net BERR_DTACK: no longer names the net of U409.5 (I/O)
- net BERR_TDI: no longer names the net of U409.7 (I/O/TDI)
- net MMUERR0: no longer names the net of U409.19 (I/O)
- net MMUERR1: no longer names the net of U409.20 (I/O)
- net MMUERR2: no longer names the net of U409.21 (I/O)
- net TCK: no longer names the net of U409.32 (I/O/TCK)
- net TDO: no longer names the net of U409.38 (I/O/TDO)
- net TMS: no longer names the net of U409.13 (I/O/TMS)
- net ~{CPU_BERR}: no longer names the net of U409.4 (I/O)
- net ~{VMEBERR}: no longer names the net of U409.24 (I/O)
Other:
- note added: "Control space (FC==4): [CTLSPDEC] xxxx.xxxx xxxx.xxxx 0000.0000 - Diagnostic display (upper digit) xxxx.xxxx xxxx.xxxx 0000.0001 - Diagnostic display (lower digit) xxxx.xxxx xxxx.xxxx 0001.000x - Configuration switches xxxx.xxxx xxxx.xxxx 0010.0000 - System Enable register [IOCTL010] xxxx.xxxx xxxx.xxxx 0100.0000 - Interrupt Set xxxx.xxxx xxxx.xxxx 0101.0000 - Interrupt Clear"
- note added: "System Enable Register Bits in the register: SYSEN_MMU 0x01 SYSEN_INT 0x02 SYSEN_SW7 0x80 All other bits reserved for future expansion."
- note removed: "Bus Error Register Bits in the register: BERR_MMUINV 0x01 BERR_MMUPROT 0x02 BERR_MMUPRIV 0x04 BERR_TIMEOUT 0x10 All other bits reserved for future expansion."
- note removed: "Control space (FC==4): [CTLSPDEC] xxxx.xxxx xxxx.xxxx 0000.0000 - Diagnostic display (upper digit) xxxx.xxxx xxxx.xxxx 0000.0001 - Diagnostic display (lower digit) xxxx.xxxx xxxx.xxxx 0001.000x - Configuration switches xxxx.xxxx xxxx.xxxx 0010.0000 - System Enable register xxxx.xxxx xxxx.xxxx 0011.0000 - Bus Error register [IOCTL010] xxxx.xxxx xxxx.xxxx 0100.0000 - Interrupt Enable xxxx.xxxx xxxx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"
- note removed: "System Enable Register Bits in the register: SYSEN_MMU 0x01 SYSEN_SW7 0x80 All other bits reserved for future expansion."
