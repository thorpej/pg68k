# Repository thorpej/pg68k (continued)

## KiCad design cpu010/design-files/cpu010.kicad_pcb (continued)

Parts:
C301, C302, C303, C304, C305, C306, C307, C308, C309, C310, C311, C312, C313, C314, C315, C316, C317, C318, C319, C320, C334: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C321, C322, C323, C324, C333: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; JLCPCB C1711
C325: 220nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; JLCPCB C5378
C326, C327, C328, C329, C330, C331, C332: 220nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C335: 100µF; CP_Radial_D6.3mm_P2.50mm; Part Wurth 860040373002; Mouser 710-860040373002
R301: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U301: ATF1508AS-TQFP100; TQFP-100_14x14mm_P0.5mm; Part ATF1508AS-7AX100; JLCPCB C1521282
U302: 61C3216; SOJ-44_10.16x28.575mm_P1.27mm; Part ISSI IS61C3216AL-12KLI; JLCPCB C2063204
U303, U304, U307, U308, U309, U310, U323, U324: 74AHCT245; DIP-20_W7.62mm_Socket; Mouser 595-SN74AHCT245N
U305, U306: 7C4098; SOJ-44_10.16x28.575mm_P1.27mm; Part Alliance AS7C4098A-12JIN; JLCPCB C2064107
U311, U312, U313: 74AHCT373; DIP-20_W7.62mm_Socket; Mouser 595-SN74AHCT373N
U314, U315, U316, U317, U318, U319, U320, U321, U322: 74AHCT157; DIP-16_W7.62mm_Socket; Mouser 595-SN74AHCT157N

Connections:
+5V: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, C319.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C327.1, C328.1, C329.1, C330.2, C331.2, C332.1, C333.1, C334.1, C335.1, U301.3 (VCCio), U301.18 (VCCio), U301.34 (VCCio), U301.39 (VCC), U301.51 (VCCio), U301.66 (VCCio), U301.82 (VCCio), U301.91 (VCC), U302.11 (VDD), U302.33 (VDD), U303.20 (VCC), U304.20 (VCC), U305.11 (VDD), U305.33 (VDD), U306.11 (VDD), U306.33 (VDD), U307.20 (VCC), U308.20 (VCC), U309.20 (VCC), U310.20 (VCC), U311.20 (VCC), U312.20 (VCC), U313.20 (VCC), U314.16 (VCC), U315.16 (VCC), U316.16 (VCC), U317.16 (VCC), U318.16 (VCC), U319.16 (VCC), U320.16 (VCC), U321.16 (VCC), U322.16 (VCC), U323.1 (A->B), U323.20 (VCC), U324.1 (A->B), U324.20 (VCC); also elsewhere on the board
/MMU/CTX0: U301.44 (I/O), U302.19 (A9)
/MMU/CTX1: U301.45 (I/O), U302.18 (A10)
/MMU/CTX2: U301.46 (I/O), U302.5 (A11)
/MMU/CTX3: U301.47 (I/O), U302.4 (A12)
/MMU/CTX4: U301.48 (I/O), U302.3 (A13)
/MMU/CTX5: U301.49 (I/O), U302.2 (A14)
/MMU/L_PMIDX0: U311.2 (O0), U314.2 (I0a)
/MMU/L_PMIDX1: U311.5 (O1), U314.5 (I0b)
/MMU/L_PMIDX2: U311.6 (O2), U314.11 (I0c)
/MMU/L_PMIDX3: U311.9 (O3), U314.14 (I0d)
/MMU/L_PMIDX4: U311.12 (O4), U315.2 (I0a)
/MMU/L_PMIDX5: U311.15 (O5), U315.5 (I0b)
/MMU/L_PMIDX6: U311.16 (O6), U315.11 (I0c)
/MMU/L_PMIDX7: U311.19 (O7), U315.14 (I0d)
/MMU/L_PMIDX8: U312.2 (O0), U316.2 (I0a)
/MMU/L_PMIDX9: U312.5 (O1), U316.5 (I0b)
/MMU/L_PMIDX10: U312.6 (O2), U316.11 (I0c)
/MMU/L_PMIDX11: U312.9 (O3), U316.14 (I0d)
/MMU/L_PMIDX12: U312.12 (O4), U317.2 (I0a)
/MMU/L_PMIDX13: U312.15 (O5), U317.5 (I0b)
/MMU/L_PMIDX14: U312.16 (O6), U317.11 (I0c)
/MMU/L_PMIDX15: U312.19 (O7), U317.14 (I0d)
/MMU/L_PMIDX16: U313.2 (O0), U318.2 (I0a)
/MMU/L_PMIDX17: U313.5 (O1), U318.5 (I0b)
/MMU/MMU_ADDR: U301.75 (I/O), U319.1 (S), U320.1 (S), U321.1 (S), U322.1 (S)
/MMU/PMACC: U301.52 (I/O), U314.1 (S), U315.1 (S), U316.1 (S), U317.1 (S), U318.1 (S)
/MMU/PMEG0: U302.7 (IO0), U304.2 (A0), U311.8 (D3)
/MMU/PMEG1: U302.8 (IO1), U304.3 (A1), U311.13 (D4)
/MMU/PMEG2: U302.9 (IO2), U304.4 (A2), U311.14 (D5)
/MMU/PMEG3: U302.10 (IO3), U304.5 (A3), U311.17 (D6)
/MMU/PMEG4: U302.13 (IO4), U304.6 (A4), U311.18 (D7)
/MMU/PMEG5: U302.14 (IO5), U304.7 (A5), U312.3 (D0)
/MMU/PMEG6: U302.15 (IO6), U304.8 (A6), U312.4 (D1)
/MMU/PMEG7: U302.16 (IO7), U304.9 (A7), U312.7 (D2)
/MMU/PMEG8: U302.29 (IO8), U303.2 (A0), U312.8 (D3)
/MMU/PMEG9: U302.30 (IO9), U303.3 (A1), U312.13 (D4)
/MMU/PMEG10: U302.31 (IO10), U303.4 (A2), U312.14 (D5)
/MMU/PMEG11: U302.32 (IO11), U303.5 (A3), U312.17 (D6)
/MMU/PMEG12: U302.35 (IO12), U303.6 (A4), U312.18 (D7)
/MMU/PMEG13: U302.36 (IO13), U303.7 (A5), U313.3 (D0)
/MMU/PMEG14: U302.37 (IO14), U303.8 (A6), U313.4 (D1)
/MMU/PME_K: U301.70 (I/O), U305.36 (IO13), U307.7 (A5)
/MMU/PME_MOD: U301.64 (I/O), U305.29 (IO8), U307.2 (A0)
/MMU/PME_PFN0: U306.7 (IO0), U310.2 (A0), U319.3 (I1a)
/MMU/PME_PFN1: U306.8 (IO1), U310.3 (A1), U319.6 (I1b)
/MMU/PME_PFN2: U306.9 (IO2), U310.4 (A2), U319.10 (I1c)
/MMU/PME_PFN3: U306.10 (IO3), U310.5 (A3), U319.13 (I1d)
/MMU/PME_PFN4: U306.13 (IO4), U310.6 (A4), U320.3 (I1a)
/MMU/PME_PFN5: U306.14 (IO5), U310.7 (A5), U320.6 (I1b)
/MMU/PME_PFN6: U306.15 (IO6), U310.8 (A6), U320.10 (I1c)
/MMU/PME_PFN7: U306.16 (IO7), U310.9 (A7), U320.13 (I1d)
/MMU/PME_PFN8: U306.29 (IO8), U309.2 (A0), U321.3 (I1a)
/MMU/PME_PFN9: U306.30 (IO9), U309.3 (A1), U321.6 (I1b)
/MMU/PME_PFN10: U306.31 (IO10), U309.4 (A2), U321.10 (I1c)
/MMU/PME_PFN11: U306.32 (IO11), U309.5 (A3), U321.13 (I1d)
/MMU/PME_PFN12: U306.35 (IO12), U309.6 (A4), U322.3 (I1a)
/MMU/PME_PFN13: U306.36 (IO13), U309.7 (A5), U322.6 (I1b)
/MMU/PME_PFN14: U306.37 (IO14), U309.8 (A6), U322.10 (I1c)
/MMU/PME_PFN15: U306.38 (IO15), U309.9 (A7), U322.13 (I1d)
/MMU/PME_REF: U301.65 (I/O), U305.30 (IO9), U307.3 (A1)
/MMU/PME_V: U301.72 (I/O), U305.38 (IO15), U307.9 (A7)
/MMU/PME_W: U301.71 (I/O), U305.37 (IO14), U307.8 (A6)
/MMU/PME_r16: U305.7 (IO0), U308.2 (A0)
/MMU/PME_r17: U305.8 (IO1), U308.3 (A1)
/MMU/PME_r18: U305.9 (IO2), U308.4 (A2)
/MMU/PME_r19: U305.10 (IO3), U308.5 (A3)
/MMU/PME_r26: U301.67 (I/O), U305.31 (IO10), U307.4 (A2)
/MMU/PME_r27: U301.68 (I/O), U305.32 (IO11), U307.5 (A3)
/MMU/PME_r28: U301.69 (I/O), U305.35 (IO12), U307.6 (A4)
/MMU/PME_s0: U305.13 (IO4), U308.6 (A4)
/MMU/PME_s1: U305.14 (IO5), U308.7 (A5)
/MMU/PME_s2: U305.15 (IO6), U308.8 (A6)
/MMU/PME_s3: U305.16 (IO7), U308.9 (A7)
/MMU/PMIDX0: U305.1 (A0), U306.1 (A0), U314.4 (Za)
/MMU/PMIDX1: U305.2 (A1), U306.2 (A1), U314.7 (Zb)
/MMU/PMIDX2: U305.3 (A2), U306.3 (A2), U314.9 (Zc)
/MMU/PMIDX3: U305.4 (A3), U306.4 (A3), U314.12 (Zd)
/MMU/PMIDX4: U305.5 (A4), U306.5 (A4), U315.4 (Za)
/MMU/PMIDX5: U305.18 (A5), U306.18 (A5), U315.7 (Zb)
/MMU/PMIDX6: U305.19 (A6), U306.19 (A6), U315.9 (Zc)
/MMU/PMIDX7: U305.20 (A7), U306.20 (A7), U315.12 (Zd)
/MMU/PMIDX8: U305.21 (A8), U306.21 (A8), U316.4 (Za)
/MMU/PMIDX9: U305.22 (A9), U306.22 (A9), U316.7 (Zb)
/MMU/PMIDX10: U305.23 (A10), U306.23 (A10), U316.9 (Zc)
/MMU/PMIDX11: U305.24 (A11), U306.24 (A11), U316.12 (Zd)
/MMU/PMIDX12: U305.25 (A12), U306.25 (A12), U317.4 (Za)
/MMU/PMIDX13: U305.26 (A13), U306.26 (A13), U317.7 (Zb)
/MMU/PMIDX14: U305.27 (A14), U306.27 (A14), U317.9 (Zc)
/MMU/PMIDX15: U305.42 (A15), U306.42 (A15), U317.12 (Zd)
/MMU/PMIDX16: U305.43 (A16), U306.43 (A16), U318.4 (Za)
/MMU/PMIDX17: U305.44 (A17), U306.44 (A17), U318.7 (Zb)
/MMU/SME_V: U301.50 (I/O), U302.38 (IO15), U303.9 (A7)
/MMU/~PMLSEL: U301.57 (I/O), U309.19 (CE), U310.19 (CE)
/MMU/~PML_LB: U301.61 (I/O), U306.39 (~LB)
/MMU/~PML_UB: U301.60 (I/O), U306.40 (~UB)
/MMU/~PML_WE: U301.58 (I/O), U306.17 (~WE)
/MMU/~PMUSEL: U301.53 (I/O), U307.19 (CE), U308.19 (CE)
/MMU/~PMU_LB: U301.56 (I/O), U305.39 (~LB)
/MMU/~PMU_UB: U301.55 (I/O), U305.40 (~UB)
/MMU/~PMU_WE: U301.54 (I/O), U305.17 (~WE)
/MMU/~PM_LE: U301.63 (I/O), U311.11 (LE), U312.11 (LE), U313.11 (LE)
/MMU/~SMSEL: U301.37 (I/O), U303.19 (CE), U304.19 (CE)
/MMU/~SM_LB: U301.42 (I/O), U302.39 (~LB)
/MMU/~SM_UB: U301.41 (I/O/PD2), U302.40 (~UB)
/MMU/~SM_WE: U301.40 (I/O), U302.17 (~WE)
A1: U323.18 (B0); also elsewhere on the board
A2: U323.17 (B1); also elsewhere on the board
A3: U323.16 (B2); also elsewhere on the board
A4: U323.15 (B3); also elsewhere on the board
A5: U323.14 (B4); also elsewhere on the board
A6: U323.13 (B5); also elsewhere on the board
A7: U323.12 (B6); also elsewhere on the board
A8: U323.11 (B7); also elsewhere on the board
A9: U324.18 (B0); also elsewhere on the board
A10: U324.17 (B1); also elsewhere on the board
A11: U324.16 (B2); also elsewhere on the board
A12: U319.4 (Za); also elsewhere on the board
A13: U319.7 (Zb); also elsewhere on the board
A14: U319.9 (Zc); also elsewhere on the board
A15: U319.12 (Zd); also elsewhere on the board
A16: U320.4 (Za); also elsewhere on the board
A17: U320.7 (Zb); also elsewhere on the board
A18: U320.9 (Zc); also elsewhere on the board
A19: U320.12 (Zd); also elsewhere on the board
A20: U321.4 (Za); also elsewhere on the board
A21: U321.7 (Zb); also elsewhere on the board
A22: U321.9 (Zc); also elsewhere on the board
A23: U321.12 (Zd); also elsewhere on the board
A24: U322.4 (Za); also elsewhere on the board
A25: U322.7 (Zb); also elsewhere on the board
A26: U322.9 (Zc); also elsewhere on the board
A27: U322.12 (Zd); also elsewhere on the board
CLK40: U301.87 (I/GCLK1); also elsewhere on the board
CPU_CLK: R301.1; also elsewhere on the board
D0: U304.18 (B0), U308.18 (B0), U310.18 (B0); also elsewhere on the board
D1: U304.17 (B1), U308.17 (B1), U310.17 (B1); also elsewhere on the board
D2: U304.16 (B2), U308.16 (B2), U310.16 (B2); also elsewhere on the board
D3: U304.15 (B3), U308.15 (B3), U310.15 (B3); also elsewhere on the board
D4: U304.14 (B4), U308.14 (B4), U310.14 (B4); also elsewhere on the board
D5: U304.13 (B5), U308.13 (B5), U310.13 (B5); also elsewhere on the board
D6: U304.12 (B6), U308.12 (B6), U310.12 (B6); also elsewhere on the board
D7: U304.11 (B7), U308.11 (B7), U310.11 (B7); also elsewhere on the board
D8: U301.19 (I/O), U303.18 (B0), U307.18 (B0), U309.18 (B0); also elsewhere on the board
D9: U301.20 (I/O), U303.17 (B1), U307.17 (B1), U309.17 (B1); also elsewhere on the board
D10: U301.21 (I/O), U303.16 (B2), U307.16 (B2), U309.16 (B2); also elsewhere on the board
D11: U301.22 (I/O), U303.15 (B3), U307.15 (B3), U309.15 (B3); also elsewhere on the board
D12: U301.23 (I/O), U303.14 (B4), U307.14 (B4), U309.14 (B4); also elsewhere on the board
D13: U301.24 (I/O), U303.13 (B5), U307.13 (B5), U309.13 (B5); also elsewhere on the board
D14: U301.25 (I/O), U303.12 (B6), U307.12 (B6), U309.12 (B6); also elsewhere on the board
D15: U301.27 (I/O), U303.11 (B7), U307.11 (B7), U309.11 (B7); also elsewhere on the board
FC0: U301.10 (I/O); also elsewhere on the board
FC1: U301.12 (I/O); also elsewhere on the board
FC2: U301.13 (I/O); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.1, C331.1, C332.2, C333.2, C334.2, C335.2, U301.11 (GND), U301.26 (GND), U301.38 (GND), U301.43 (GND), U301.59 (GND), U301.74 (GND), U301.86 (GND), U301.95 (GND), U302.6 (~CE), U302.12 (GND), U302.34 (GND), U302.41 (~OE), U303.10 (GND), U304.10 (GND), U305.6 (~CE), U305.12 (GND), U305.34 (GND), U305.41 (~OE), U306.6 (~CE), U306.12 (GND), U306.34 (GND), U306.41 (~OE), U307.10 (GND), U308.10 (GND), U309.10 (GND), U310.10 (GND), U311.1 (OE), U311.10 (GND), U312.1 (OE), U312.10 (GND), U313.1 (OE), U313.7 (D2), U313.8 (D3), U313.10 (GND), U313.13 (D4), U313.14 (D5), U313.17 (D6), U313.18 (D7), U314.8 (GND), U314.15 (E), U315.8 (GND), U315.15 (E), U316.8 (GND), U316.15 (E), U317.8 (GND)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; also elsewhere on the board
IOCTL_TDI: U301.73 (I/O/TDO); also elsewhere on the board
MMU_DTACK: U301.1 (I/O/PD1); also elsewhere on the board
MMU_EN: U301.88 (I/OE1/Vpp); also elsewhere on the board
MMU_TDI: U301.4 (I/O/TDI); also elsewhere on the board
unnamed: R301.2, U301.100 (I/O)
R/~W: U301.6 (I/O), U303.1 (A->B), U304.1 (A->B), U307.1 (A->B), U308.1 (A->B), U309.1 (A->B), U310.1 (A->B); also elsewhere on the board
TCK: U301.62 (I/O/TCK); also elsewhere on the board
TMS: U301.15 (I/O/TMS); also elsewhere on the board
VA1: U301.14 (I/O), U323.2 (A0); also elsewhere on the board
VA2: U301.16 (I/O), U323.3 (A1); also elsewhere on the board
VA3: U301.17 (I/O), U323.4 (A2); also elsewhere on the board
VA4: U314.3 (I1a), U323.5 (A3); also elsewhere on the board
VA5: U314.6 (I1b), U323.6 (A4); also elsewhere on the board
VA6: U314.10 (I1c), U323.7 (A5); also elsewhere on the board
VA7: U314.13 (I1d), U323.8 (A6); also elsewhere on the board
VA8: U315.3 (I1a), U323.9 (A7); also elsewhere on the board
VA9: U315.6 (I1b), U324.2 (A0); also elsewhere on the board
VA10: U315.10 (I1c), U324.3 (A1); also elsewhere on the board
VA11: U315.13 (I1d), U324.4 (A2); also elsewhere on the board
VA12: U311.3 (D0), U316.3 (I1a), U319.2 (I0a); also elsewhere on the board
VA13: U311.4 (D1), U316.6 (I1b), U319.5 (I0b); also elsewhere on the board
VA14: U311.7 (D2), U316.10 (I1c), U319.11 (I0c); also elsewhere on the board
VA15: U302.44 (A0), U316.13 (I1d), U319.14 (I0d); also elsewhere on the board
VA16: U302.43 (A1), U317.3 (I1a), U320.2 (I0a); also elsewhere on the board
VA17: U302.42 (A2), U317.6 (I1b), U320.5 (I0b); also elsewhere on the board
VA18: U302.27 (A3), U317.10 (I1c), U320.11 (I0c); also elsewhere on the board
VA19: U302.26 (A4), U317.13 (I1d), U320.14 (I0d); also elsewhere on the board
VA20: U302.25 (A5), U318.3 (I1a), U321.2 (I0a); also elsewhere on the board
VA21: U302.24 (A6), U318.6 (I1b), U321.5 (I0b); also elsewhere on the board
VA22: U302.21 (A7), U321.11 (I0c); also elsewhere on the board
VA23: U302.20 (A8), U321.14 (I0d); also elsewhere on the board
~AS: U301.76 (I/O); also elsewhere on the board
~CPU_AS: U301.5 (I/O); also elsewhere on the board
~CPU_BERR: U301.28 (I/O); also elsewhere on the board
~CPU_LDS: U301.8 (I/O); also elsewhere on the board
~CPU_UDS: U301.7 (I/O); also elsewhere on the board
~DTACK: U301.9 (I/O); also elsewhere on the board
~EXP_BERR: U301.85 (I/O/GCLK3); also elsewhere on the board
~LDS: U301.78 (I/O); also elsewhere on the board
~RESET: U301.89 (I/GCLR); also elsewhere on the board
~UDS: U301.77 (I/O); also elsewhere on the board

Parts:
BT601: CR1220; BatteryHolder_Keystone_500
C601, C602, C603, C604, C605, C606, C607, C608: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C609, C610: 100µF; CP_Radial_D6.3mm_P2.50mm; Part Wurth 860040373002
D601: ATA Active; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J601: UART0 FTDI; PinHeader_1x06_P2.54mm_Horizontal
J602: UART1 FTDI; PinHeader_1x06_P2.54mm_Horizontal
J603: UART0; IDC-Header_2x05_P2.54mm_Vertical
J604: UART1; IDC-Header_2x05_P2.54mm_Vertical
J605: ATA Connector; IDC-Header_2x20_P2.54mm_Vertical
J606: 5V CF Power; PinHeader_1x04_P2.54mm_Vertical
J607: I2C; PinHeader_1x04_P2.54mm_Vertical
R601, R602, R605, R612: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R603, R606, R607, R613: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R604: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R608, R609, R610, R611: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN601, RN603, RN604, RN605: 10K; R_Array_SIP9; Mouser 652-4609X-1LF-10K
RN602: 3K3; R_Array_SIP9; Mouser 652-4609X-1LF-3.3K
U601: ATF1508AS-TQFP100; TQFP-100_14x14mm_P0.5mm; Part ATF1508AS-7AX100; JLCPCB C1521282
U602: TL16C2552; PLCC-44_THT-Socket; Mouser 595-TL16C2552FN
U603: PCF8584; DIP-20_W7.62mm_Socket
U604: DS3231MZ+; SOIC-8_3.9x4.9mm_P1.27mm; Mouser 700-DS3231MZ+
U605, U606, U607: 74ACT245; DIP-20_W7.62mm_Socket; Mouser 595-SN74ACT245N
Y601: 1.8432MHz; Oscillator_DIP-8; Part MXO45HST-3C-1M8432; Mouser 774-MXO45HST-3C-1.8

Connections:
+5V: C601.1, C602.2, C603.1, C604.1, C605.1, C606.1, C607.1, C608.1, C609.1, C610.1, J603.10, J604.10, J606.1, J607.1, R601.1, R602.1, R604.2, R605.1, R612.1, R613.1, RN601.1 (common), RN602.1 (common), RN603.1 (common), RN604.1 (common), RN605.1 (common), U601.3 (VCCio), U601.18 (VCCio), U601.34 (VCCio), U601.39 (VCC), U601.51 (VCCio), U601.66 (VCCio), U601.82 (VCCio), U601.91 (VCC), U602.33 (VCC), U602.44 (VCC), U603.20 (VDD), U604.2 (VCC), U605.20 (VCC), U606.20 (VCC), U607.20 (VCC), Y601.1 (EN), Y601.8 (Vcc); also elsewhere on the board
/On-board IO/ATA_A0: J605.35, RN605.7 (R6), U607.4 (A2)
/On-board IO/ATA_A1: J605.33, RN605.5 (R4), U607.5 (A3)
/On-board IO/ATA_A2: J605.36, RN605.6 (R5), U607.6 (A4)
/On-board IO/ATA_D0: J605.17, RN603.9 (R8), U606.2 (A0)
/On-board IO/ATA_D1: J605.15, RN603.8 (R7), U606.3 (A1)
/On-board IO/ATA_D2: J605.13, RN603.7 (R6), U606.4 (A2)
/On-board IO/ATA_D3: J605.11, RN603.6 (R5), U606.5 (A3)
/On-board IO/ATA_D4: J605.9, RN603.5 (R4), U606.6 (A4)
/On-board IO/ATA_D5: J605.7, RN603.4 (R3), U606.7 (A5)
/On-board IO/ATA_D6: J605.5, RN603.3 (R2), U606.8 (A6)
/On-board IO/ATA_D7: J605.3, RN603.2 (R1), U606.9 (A7)
/On-board IO/ATA_D8: J605.4, RN604.2 (R1), U605.2 (A0)
/On-board IO/ATA_D9: J605.6, RN604.3 (R2), U605.3 (A1)
/On-board IO/ATA_D10: J605.8, RN604.4 (R3), U605.4 (A2)
/On-board IO/ATA_D11: J605.10, RN604.5 (R4), U605.5 (A3)
/On-board IO/ATA_D12: J605.12, RN604.6 (R5), U605.6 (A4)
/On-board IO/ATA_D13: J605.14, RN604.7 (R6), U605.7 (A5)
/On-board IO/ATA_D14: J605.16, RN604.8 (R7), U605.8 (A6)
/On-board IO/ATA_D15: J605.18, RN604.9 (R8), U605.9 (A7)
/On-board IO/ATA_INT: J605.31, R603.2, U601.81 (I/O)
/On-board IO/ATA_RDY: J605.27, R612.2, U601.72 (I/O)
/On-board IO/IO_RST: U601.2 (I/O), U602.21 (RESET)
/On-board IO/UARTA_INT: R607.2, U601.84 (I/O), U602.34 (INTA)
/On-board IO/UARTA_RXD: J602.4, J604.2, U602.39 (RXA)
/On-board IO/UARTA_TXD: J602.5, J604.3, U602.38 (TXA)
/On-board IO/UARTB_INT: R606.2, U601.85 (I/O/GCLK3), U602.17 (INTB)
/On-board IO/UARTB_RXD: J601.4, J603.2, U602.25 (RXB)
/On-board IO/UARTB_TXD: J601.5, J603.3, U602.26 (TXB)
/On-board IO/~ATAAUXSEL: U601.80 (I/O), U607.17 (B1)
/On-board IO/~ATABEN: U601.78 (I/O), U605.19 (CE), U606.19 (CE)
/On-board IO/~ATASEL: U601.79 (I/O), U607.18 (B0)
/On-board IO/~ATA_CS1FX: J605.37, R608.2, RN605.9 (R8)
/On-board IO/~ATA_CS3FX: J605.38, R609.2, RN605.8 (R7)
/On-board IO/~ATA_IORD: J605.25, R610.2, RN605.3 (R2)
/On-board IO/~ATA_IOWR: J605.23, R611.2, RN605.2 (R1)
/On-board IO/~ATA_RST: J605.1, RN605.4 (R3), U607.7 (A5)
/On-board IO/~DUARTSEL: U601.83 (I/O), U602.18 (~CS)
/On-board IO/~I2CSEL: U601.77 (I/O), U603.17 (~CS)
/On-board IO/~I2C_INT: R605.2, U601.76 (I/O), U603.5 (~INT)
/On-board IO/~IO_RD: U601.98 (I/O), U602.24 (~IOR), U607.12 (B6)
/On-board IO/~IO_WR: U601.99 (I/O), U602.20 (~IOW), U607.11 (B7)
/On-board IO/~UARTA_CD: J604.1, RN601.7 (R6), U602.42 (~CDA)
/On-board IO/~UARTA_CTS: J602.6, J604.8, RN601.9 (R8), U602.40 (~CTSA)
/On-board IO/~UARTA_DSR: J604.6, RN601.8 (R7), U602.41 (~DSRA)
/On-board IO/~UARTA_DTR: J604.4, U602.37 (~DTRA)
/On-board IO/~UARTA_RI: J604.9, RN601.6 (R5), U602.43 (~RIA)
/On-board IO/~UARTA_RTS: J602.2, J604.7, U602.36 (~RTSA)
/On-board IO/~UARTB_CD: J603.1, RN601.3 (R2), U602.30 (~CDB)
/On-board IO/~UARTB_CTS: J601.6, J603.8, RN601.5 (R4), U602.28 (~CTSB)
/On-board IO/~UARTB_DSR: J603.6, RN601.4 (R3), U602.29 (~DSRB)
/On-board IO/~UARTB_DTR: J603.4, U602.27 (~DTRB)
/On-board IO/~UARTB_RI: J603.9, RN601.2 (R1), U602.31 (~RIB)
/On-board IO/~UARTB_RTS: J601.2, J603.7, U602.23 (~RTSB)
A26: U601.42 (I/O); also elsewhere on the board
A27: U601.44 (I/O); also elsewhere on the board
CPU_CLK: U601.87 (I/GCLK1), U603.1 (CLK); also elsewhere on the board
D0: U605.18 (B0); also elsewhere on the board
D1: U605.17 (B1); also elsewhere on the board
D2: U605.16 (B2); also elsewhere on the board
D3: U605.15 (B3); also elsewhere on the board
D4: U605.14 (B4); also elsewhere on the board
D5: U605.13 (B5); also elsewhere on the board
D6: U605.12 (B6); also elsewhere on the board
D7: U605.11 (B7); also elsewhere on the board
D8: U601.19 (I/O), U602.2 (D0), U603.7 (D0), U606.18 (B0); also elsewhere on the board
D9: U601.20 (I/O), U602.3 (D1), U603.8 (D1), U606.17 (B1); also elsewhere on the board
D10: U601.21 (I/O), U602.4 (D2), U603.9 (D2), U606.16 (B2); also elsewhere on the board
D11: U601.22 (I/O), U602.5 (D3), U603.11 (D3), U606.15 (B3); also elsewhere on the board
D12: U601.23 (I/O), U602.6 (D4), U603.12 (D4), U606.14 (B4); also elsewhere on the board
D13: U601.24 (I/O), U602.7 (D5), U603.13 (D5), U606.13 (B5); also elsewhere on the board
D14: U601.25 (I/O), U602.8 (D6), U603.14 (D6), U606.12 (B6); also elsewhere on the board
D15: U601.27 (I/O), U602.9 (D7), U603.15 (D7), U606.11 (B7); also elsewhere on the board
FC0: U601.10 (I/O); also elsewhere on the board
FC1: U601.12 (I/O); also elsewhere on the board
FC2: U601.13 (I/O); also elsewhere on the board
GND: BT601.2 (-), C601.2, C602.1, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, J601.1, J602.1, J603.5, J604.5, J605.2, J605.19, J605.22, J605.24, J605.26, J605.30, J605.40, J606.2, J606.3, J607.4, R603.1, R606.1, R607.1, U601.11 (GND), U601.26 (GND), U601.38 (GND), U601.43 (GND), U601.59 (GND), U601.74 (GND), U601.86 (GND), U601.95 (GND), U602.12 (GND), U602.22 (GND), U603.10 (VSS), U604.5 (GND), U605.10 (GND), U606.10 (GND), U607.1 (A->B), U607.10 (GND), U607.19 (CE), Y601.4 (GND); also elsewhere on the board
INT_EN: U601.49 (I/O); also elsewhere on the board
IOCTL_DTACK: U601.1 (I/O/PD1); also elsewhere on the board
IOCTL_TDI: U601.4 (I/O/TDI); also elsewhere on the board
IPL0: U601.14 (I/O); also elsewhere on the board
IPL1: U601.16 (I/O); also elsewhere on the board
IPL2: U601.17 (I/O); also elsewhere on the board
MEMCTL_TDI: U601.73 (I/O/TDO); also elsewhere on the board
unnamed: BT601.1 (+), U604.6 (VBAT)
unnamed: D601.2 (A), R604.1
unnamed: D601.1 (K), J605.39, R613.2
unnamed: U602.11 (XIN), Y601.5 (OUT)
unnamed: R608.1, U607.2 (A0)
unnamed: R609.1, U607.3 (A1)
unnamed: R610.1, U607.8 (A6)
unnamed: R611.1, U607.9 (A7)
R/~W: U601.6 (I/O), U603.18 (~WR), U605.1 (A->B), U606.1 (A->B); also elsewhere on the board
SCL: J607.3, R602.2, U603.3 (SCL), U604.8 (SCL); also elsewhere on the board
SDA: J607.2, R601.2, U603.2 (SDA), U604.7 (SDA); also elsewhere on the board
TCK: U601.62 (I/O/TCK); also elsewhere on the board
TMS: U601.15 (I/O/TMS); also elsewhere on the board
VA1: U601.28 (I/O), U602.10 (A0), U603.6 (A0), U607.16 (B2); also elsewhere on the board
VA2: U601.29 (I/O), U602.14 (A1), U607.15 (B3); also elsewhere on the board
VA3: U601.30 (I/O), U602.15 (A2), U607.14 (B4); also elsewhere on the board
VA4: U601.31 (I/O); also elsewhere on the board
VA5: U601.32 (I/O); also elsewhere on the board
VA6: U601.33 (I/O); also elsewhere on the board
VA7: U601.35 (I/O); also elsewhere on the board
VA8: U601.36 (I/O), U602.16 (CHSEL); also elsewhere on the board
VA9: U601.37 (I/O); also elsewhere on the board
VA10: U601.40 (I/O); also elsewhere on the board
VA11: U601.41 (I/O/PD2); also elsewhere on the board
VA16: U601.45 (I/O); also elsewhere on the board
VA17: U601.46 (I/O); also elsewhere on the board
VA18: U601.47 (I/O); also elsewhere on the board
VA19: U601.48 (I/O); also elsewhere on the board
~AS: U601.5 (I/O); also elsewhere on the board
~DTACK: U603.16 (~RD); also elsewhere on the board
~EXPSEL: U601.75 (I/O); also elsewhere on the board
~IRQ3: RN602.2 (R1), U601.92 (I/O); also elsewhere on the board
~IRQ4: RN602.3 (R2), U601.93 (I/O); also elsewhere on the board
~IRQ5: RN602.4 (R3), U601.94 (I/O); also elsewhere on the board
~IRQ6: RN602.5 (R4), U601.96 (I/O); also elsewhere on the board
~IRQ7: RN602.6 (R5), U601.97 (I/O)
~LDS: U601.8 (I/O); also elsewhere on the board
~RESET: U601.89 (I/GCLR), U603.19 (~RST), U607.13 (B5); also elsewhere on the board
~UDS: U601.7 (I/O); also elsewhere on the board
~VPA: U601.100 (I/O); also elsewhere on the board

Notes on the sheet:
FTDI connector: 1=GND 2=CTS 3=Vcc 4=TxD 5=RxD 6=CTS Both ports configured as NULL modem.
NOTE: UART0 (console) -> channel B (A8=0) IDC 10 connectors are pinned the same as RS232 DB9, with +5V being provided on pin 10. This allows for a remote board with RS232 line drivers to be added. Note: Only connect one kind of external interface to a port at any given time.
