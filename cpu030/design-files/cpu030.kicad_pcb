File: cpu030/design-files/cpu030.kicad_pcb (KiCad board)
At the start: 4 copper layers, 94 parts, among them J101 Reset, J102 SYSCTL JTAG, J201 DRAM0SZ, J202 DRAM0 JTAG, J301 UART0 FTDI, J302 UART1 FTDI, J303 UART1, J304 UART0, SW101 Reset button, U101 MC68030RC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

Commit message: Add INTC-1.
Parts:
- added C131: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (294.3, 198.1)
- added C132: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (314.5, 180.1)
- added U108: GAL22V10, Package_DIP:DIP-24_W7.62mm_Socket, F.Cu at (305.9, 182.7)
- added U109: MC74ACT05DG, Package_SO:SOIC-14_3.9x8.7mm_P1.27mm, F.Cu at (299.0, 195.4)
Routing:
- net +5V: track 149.9 -> 154.8 mm
Other:
- board text added: "INTC-1"

Commit message: Add data bus pullups.
Parts:
- added RN102: 10K, Resistor_THT:R_Array_SIP9, F.Cu at (238.2, 169.7)
- added RN103: 10K, Resistor_THT:R_Array_SIP9, F.Cu at (300.9, 151.9)
- added RN104: 10K, Resistor_THT:R_Array_SIP9, F.Cu at (238.2, 151.8)
- added RN105: 10K, Resistor_THT:R_Array_SIP9, F.Cu at (300.9, 169.7)
- moved D101 78.4 mm to (272.9, 219.1)
- moved J101 78.4 mm to (297.9, 220.7)
- moved R101 78.4 mm to (278.6, 222.3)
- moved U104 78.4 mm to (273.9, 223.3)
- moved SW101 78.4 mm to (284.1, 219.3)

Commit message: Move the data bus pullups over by the fast RAM.
Parts:
- moved RN105 149.2 mm to (159.5, 217.6)
- moved RN103 134.9 mm to (183.0, 217.6)
- moved RN104 100.6 mm to (159.5, 214.5)
- moved RN102 71.0 mm to (183.0, 214.5)
Changed lines of the file:
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@@
 	(footprint "Resistor_THT:R_Array_SIP9"
 		(layer "F.Cu")
-		(at 300.863 151.8666)
+		(at 183.0324 217.6272)
 		(descr "9-pin Resistor SIP pack")
 		(tags "R")
 		(property "Reference" "RN103"
-			(at 24.3586 0 0)
+			(at 24.3586 -0.8128 0)
 			(layer "F.SilkS")
 			(effects
@@
 		)
 		(property "Value" "10K"
-			(at 11.43 2.31 0)
+			(at 24.4602 0.7112 0)
 			(layer "F.SilkS")
 			(effects
@@
 	(footprint "Resistor_THT:R_Array_SIP9"
 		(layer "F.Cu")
-		(at 238.1758 169.7228)
+		(at 183.0324 214.503)
 		(descr "9-pin Resistor SIP pack")
 		(tags "R")
 		(property "Reference" "RN102"
-			(at 24.4602 0.0508 0)
+			(at 24.4602 -0.8128 0)
 			(layer "F.SilkS")
 			(effects
@@
 		)
 		(property "Value" "10K"
-			(at 11.43 2.31 0)
+			(at 24.4602 0.7112 0)
 			(layer "F.SilkS")
 			(effects
@@
 	(footprint "Resistor_THT:R_Array_SIP9"
 		(layer "F.Cu")
-		(at 238.1758 151.8412)
+		(at 159.512 214.503)
 		(descr "9-pin Resistor SIP pack")
 		(tags "R")
 		(property "Reference" "RN104"
-			(at 24.3078 0.0254 0)
+			(at -4.0386 -0.8128 0)
 			(layer "F.SilkS")
 			(effects
@@
 		)
 		(property "Value" "10K"
-			(at 11.43 2.31 0)
+			(at -3.9116 0.7112 0)
 			(layer "F.SilkS")
 			(effects
@@
 	(footprint "Resistor_THT:R_Array_SIP9"
 		(layer "F.Cu")
-		(at 300.863 169.7228)
+		(at 159.512 217.6272)
 		(descr "9-pin Resistor SIP pack")
 		(tags "R")
 		(property "Reference" "RN105"
-			(at 24.3332 0.0254 0)
+			(at -4.0386 -0.8128 0)
 			(layer "F.SilkS")
 			(effects
@@
 		)
 		(property "Value" "10K"
-			(at 11.43 2.31 0)
+			(at -3.9116 0.7112 0)
 			(layer "F.SilkS")
 			(effects

Commit message: Reset circuit.
Parts:
- added C101: 100µF, Capacitor_Tantalum_SMD:CP_EIA-6032-15_Kemet-U_HandSolder, F.Cu at (218.3, 217.9)
- SW101: value Reset button -> Reset
- moved J101 138.9 mm to (159.2, 227.4)
- moved SW101 70.4 mm to (214.2, 227.7)
- moved R101 65.4 mm to (213.3, 219.7)
- moved U104 60.9 mm to (213.3, 216.6), turned to 90 degrees
- moved D101 51.1 mm to (221.9, 214.5), turned to -90 degrees

Commit message: Add NMI button.
Parts:
- added J103: NMI, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, F.Cu at (163.2, 227.4)
- added SW102: NMI, Button_Switch_THT:SW_PUSH_6mm, F.Cu at (295.7, 227.7)
- added U110: DS1813, Package_TO_SOT_SMD:SOT-23-3, F.Cu at (299.0, 204.1)

Commit message: System timer.
Parts:
- added C401: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (228.7, 95.6)
- added C402: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (211.8, 95.7)
- added U401: CP82C54-10Z, Package_DIP:DIP-24_W15.24mm_Socket, F.Cu at (214.4, 98.2)
- added U402: GAL22V10, Package_DIP:DIP-24_W7.62mm_Socket, F.Cu at (203.2, 98.3)
Routing:
- net +5V: track 154.8 -> 160.1 mm
Other:
- board outline added: 200 x 154.9 mm
- board text added: "TMRGLUE"
