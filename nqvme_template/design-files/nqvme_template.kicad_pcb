# Repository thorpej/pg68k (continued)

## KiCad design cpu010/design-files/cpu010.kicad_pcb (continued)

Parts:
C401, C402, C403, C404, C405, C406, C407, C412, C413, C414, C415, C416, C417, C418, C419: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
RN401, RN402: 470R; DIP-16_W7.62mm_Socket; Part Bourns 4116R-1-471LF; Mouser 652-4116R-1LF-470
RN403, RN404: 47K; R_Array_SIP9; Mouser 652-4609X-1LF-47K
SW401, SW402: SW_DIP_x08; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U401: DA04-11SURKWA; Mouser 604-DA04-11SURKWA
U402, U403, U407: 74HCT273; DIP-20_W7.62mm_Socket; Mouser 595-CD74HCT237E
U404: GAL22V10; DIP-24_W7.62mm_Socket; Mouser 556-AF22V10C15PU
U405, U406, U408: 74HCT245; DIP-20_W7.62mm_Socket; Mouser 595-SN74HCT245NE4

Connections:
+5V: C401.1, C402.1, C403.1, C404.2, C405.2, C406.1, C407.1, C412.1, C413.1, C414.1, C415.1, C416.1, C417.1, C418.2, C419.2, SW401.9, SW401.10, SW401.11, SW401.12, SW401.13, SW401.14, SW401.15, SW401.16, SW402.9, SW402.10, SW402.11, SW402.12, SW402.13, SW402.14, SW402.15, SW402.16, U401.4 (DIG1_CA), U401.5 (DIG2_CA), U402.20 (VCC), U403.20 (VCC), U404.24 (VCC), U405.20 (VCC), U406.20 (VCC), U407.20 (VCC), U408.20 (VCC); also elsewhere on the board
/Control Space/~CSLSEL: U404.19 (IO6), U406.19 (CE)
/Control Space/~CSUSEL: U404.18 (IO5), U405.19 (CE)
/Control Space/~DDLSEL: U403.11 (Cp), U404.17 (IO4)
/Control Space/~DDUSEL: U402.11 (Cp), U404.16 (IO3)
/Control Space/~ERRD: U404.20 (IO7), U408.19 (CE)
/Control Space/~ERWR: U404.21 (IO8), U407.11 (Cp)
CTLSP_DTACK: U404.23 (IO10); also elsewhere on the board
D0: U403.3 (D0), U406.2 (A0); also elsewhere on the board
D1: U403.4 (D1), U406.3 (A1); also elsewhere on the board
D2: U403.7 (D2), U406.4 (A2); also elsewhere on the board
D3: U403.8 (D3), U406.5 (A3); also elsewhere on the board
D4: U403.13 (D4), U406.6 (A4); also elsewhere on the board
D5: U403.14 (D5), U406.7 (A5); also elsewhere on the board
D6: U403.17 (D6), U406.8 (A6); also elsewhere on the board
D7: U403.18 (D7), U406.9 (A7); also elsewhere on the board
D8: U402.3 (D0), U405.2 (A0), U407.3 (D0), U408.2 (A0); also elsewhere on the board
D9: U402.4 (D1), U405.3 (A1), U407.4 (D1), U408.3 (A1); also elsewhere on the board
D10: U402.7 (D2), U405.4 (A2), U407.7 (D2), U408.4 (A2); also elsewhere on the board
D11: U402.8 (D3), U405.5 (A3), U407.8 (D3), U408.5 (A3); also elsewhere on the board
D12: U402.13 (D4), U405.6 (A4), U407.13 (D4), U408.6 (A4); also elsewhere on the board
D13: U402.14 (D5), U405.7 (A5), U407.14 (D5), U408.7 (A5); also elsewhere on the board
D14: U402.17 (D6), U405.8 (A6), U407.17 (D6), U408.8 (A6); also elsewhere on the board
D15: U402.18 (D7), U405.9 (A7), U407.18 (D7), U408.9 (A7); also elsewhere on the board
FC0: U404.1 (I1/CLK); also elsewhere on the board
FC1: U404.2 (I2); also elsewhere on the board
FC2: U404.3 (I3); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.1, C405.1, C406.2, C407.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.1, C419.1, RN403.1 (common), RN404.1 (common), U402.10 (GND), U403.10 (GND), U404.12 (GND), U405.1 (A->B), U405.10 (GND), U406.1 (A->B), U406.10 (GND), U407.10 (GND), U408.1 (A->B), U408.10 (GND); also elsewhere on the board
INT_EN: U407.5 (Q1), U408.17 (B1); also elsewhere on the board
MMU_EN: U407.2 (Q0), U408.18 (B0); also elsewhere on the board
unnamed: RN401.1 (R1.1), U401.15 (DIG1_A)
unnamed: RN401.16 (R1.2), U402.2 (Q0)
unnamed: RN401.2 (R2.1), U401.13 (DIG1_B)
unnamed: RN401.15 (R2.2), U402.5 (Q1)
unnamed: RN401.3 (R3.1), U401.1 (DIG1_C)
unnamed: RN401.14 (R3.2), U402.6 (Q2)
unnamed: RN401.4 (R4.1), U401.3 (DIG1_D)
unnamed: RN401.13 (R4.2), U402.9 (Q3)
unnamed: RN401.5 (R5.1), U401.2 (DIG1_E)
unnamed: RN401.12 (R5.2), U402.12 (Q4)
unnamed: RN401.6 (R6.1), U401.14 (DIG1_F)
unnamed: RN401.11 (R6.2), U402.15 (Q5)
unnamed: RN401.7 (R7.1), U401.16 (DIG1_G)
unnamed: RN401.10 (R7.2), U402.16 (Q6)
unnamed: RN401.9 (R8.2), U402.19 (Q7)
unnamed: RN402.1 (R1.1), U401.10 (DIG2_A)
unnamed: RN402.16 (R1.2), U403.2 (Q0)
unnamed: RN402.2 (R2.1), U401.12 (DIG2_B)
unnamed: RN402.15 (R2.2), U403.5 (Q1)
unnamed: RN402.3 (R3.1), U401.8 (DIG2_C)
unnamed: RN402.14 (R3.2), U403.6 (Q2)
unnamed: RN402.4 (R4.1), U401.6 (DIG2_D)
unnamed: RN402.13 (R4.2), U403.9 (Q3)
unnamed: RN402.5 (R5.1), U401.7 (DIG2_E)
unnamed: RN402.12 (R5.2), U403.12 (Q4)
unnamed: RN402.6 (R6.1), U401.11 (DIG2_F)
unnamed: RN402.11 (R6.2), U403.15 (Q5)
unnamed: RN402.7 (R7.1), U401.9 (DIG2_G)
unnamed: RN402.10 (R7.2), U403.16 (Q6)
unnamed: RN402.9 (R8.2), U403.19 (Q7)
unnamed: RN403.2 (R1), SW401.8, U405.18 (B0)
unnamed: RN403.3 (R2), SW401.7, U405.17 (B1)
unnamed: RN403.4 (R3), SW401.6, U405.16 (B2)
unnamed: RN403.5 (R4), SW401.5, U405.15 (B3)
unnamed: RN403.6 (R5), SW401.4, U405.14 (B4)
unnamed: RN403.7 (R6), SW401.3, U405.13 (B5)
unnamed: RN403.8 (R7), SW401.2, U405.12 (B6)
unnamed: RN403.9 (R8), SW401.1, U405.11 (B7)
unnamed: RN404.2 (R1), SW402.8, U406.18 (B0)
unnamed: RN404.3 (R2), SW402.7, U406.17 (B1)
unnamed: RN404.4 (R3), SW402.6, U406.16 (B2)
unnamed: RN404.5 (R4), SW402.5, U406.15 (B3)
unnamed: RN404.6 (R5), SW402.4, U406.14 (B4)
unnamed: RN404.7 (R6), SW402.3, U406.13 (B5)
unnamed: RN404.8 (R7), SW402.2, U406.12 (B6)
unnamed: RN404.9 (R8), SW402.1, U406.11 (B7)
unnamed: U407.6 (Q2), U408.16 (B2)
unnamed: U407.9 (Q3), U408.15 (B3)
unnamed: U407.12 (Q4), U408.14 (B4)
unnamed: U407.15 (Q5), U408.13 (B5)
unnamed: U407.16 (Q6), U408.12 (B6)
unnamed: U407.19 (Q7), U408.11 (B7)
R/~W: U404.14 (IO1); also elsewhere on the board
VA1: U404.4 (I4); also elsewhere on the board
VA2: U404.5 (I5); also elsewhere on the board
VA3: U404.6 (I6); also elsewhere on the board
VA4: U404.7 (I7); also elsewhere on the board
VA5: U404.8 (I8); also elsewhere on the board
VA6: U404.9 (I9); also elsewhere on the board
VA7: U404.10 (I10); also elsewhere on the board
~CPU_LDS: U404.13 (I12); also elsewhere on the board
~CPU_UDS: U404.11 (I11); also elsewhere on the board
~RESET: U402.1 (~Mr), U403.1 (~Mr), U407.1 (~Mr); also elsewhere on the board

Notes on the sheet:
Control space (FC==4): [CTLSPDEC] xxxx.xxxx xxxx.xxxx 0000.0000 - Diagnostic display (upper digit) xxxx.xxxx xxxx.xxxx 0000.0001 - Diagnostic display (lower digit) xxxx.xxxx xxxx.xxxx 0001.000x - Configuration switches xxxx.xxxx xxxx.xxxx 0010.0000 - System Enable register [IOCTL010] xxxx.xxxx xxxx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
System Enable Register Bits in the register: SYSEN_MMU 0x01 SYSEN_INT 0x02 SYSEN_SW7 0x80 All other bits reserved for future expansion.
Diagnostic Display Register
Configuration Register

Parts:
C701, C702, C703, C704, C705, C706, C707, C709, C710, C712: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C708, C711, C713: 100µF; CP_Radial_D6.3mm_P2.50mm; Part Wurth 860040373002; Mouser 710-860040373002
J701: NQVME Slot 1; DIN41612_C_3x32_Female_Vertical_THT
J702: NQVME Slot 2; DIN41612_C_3x32_Female_Vertical_THT
J703: NQVME Slot 3; DIN41612_C_3x32_Female_Vertical_THT
R701, R702, R703, R704, R705, R706, R707: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R708: 4K7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R709: 3K3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN701, RN702, RN703, RN704, RN705, RN706, RN707: 330R/470R; R_Array_SIP10; Part Bourns 4610X-104-331/471L; Mouser 652-4610X104331/471L
U701, U702, U705, U706, U707: 74ACT245; DIP-20_W7.62mm_Socket; Mouser 595-SN74ACT245N
U703: GAL22V10; DIP-24_W7.62mm_Socket; Mouser 556-AF22V10C15PU
U704: 74ACT32; DIP-14_W7.62mm_Socket; Mouser 595-SN74ACT32N
U708: L272D; SOIC-16_3.9x9.9mm_P1.27mm; Mouser 511-L272D013TR

Connections:
+5V: C701.1, C702.1, C703.1, C704.1, C705.1, C706.1, C707.1, C708.1, C709.1, J701.a32, J701.b32, J701.c32, J702.a32, J702.b32, J702.c32, J703.a32, J703.b32, J703.c32, R701.1, R702.1, R703.1, R704.1, R706.1, R707.1, R709.1, U701.20 (VCC), U702.20 (VCC), U703.24 (VCC), U704.14 (VCC), U705.1 (A->B), U705.20 (VCC), U706.1 (A->B), U706.20 (VCC), U707.1 (A->B), U707.20 (VCC), U708.4 (V+); also elsewhere on the board
+5Vsb: J701.b31, J702.b31, J703.b31; also elsewhere on the board
+12V: J701.c31, J702.c31, J703.c31; also elsewhere on the board
-12V: J701.a31, J702.a31, J703.a31; also elsewhere on the board
/Expansion/EXP_A1: J701.a30, J702.a30, J703.a30, RN704.8 (R7), U705.12 (B6)
/Expansion/EXP_A2: J701.a29, J702.a29, J703.a29, RN704.7 (R6), U705.13 (B5)
/Expansion/EXP_A3: J701.a28, J702.a28, J703.a28, RN704.6 (R5), U705.14 (B4)
/Expansion/EXP_A4: J701.a27, J702.a27, J703.a27, RN704.5 (R4), U705.15 (B3)
/Expansion/EXP_A5: J701.a26, J702.a26, J703.a26, RN704.4 (R3), U705.16 (B2)
/Expansion/EXP_A6: J701.a25, J702.a25, J703.a25, RN704.3 (R2), U705.17 (B1)
/Expansion/EXP_A7: J701.a24, J702.a24, J703.a24, RN704.2 (R1), U705.18 (B0)
/Expansion/EXP_A8: J701.c30, J702.c30, J703.c30, RN704.9 (R8), U705.11 (B7)
/Expansion/EXP_A9: J701.c29, J702.c29, J703.c29, RN705.9 (R8), U706.11 (B7)
/Expansion/EXP_A10: J701.c28, J702.c28, J703.c28, RN705.8 (R7), U706.12 (B6)
/Expansion/EXP_A11: J701.c27, J702.c27, J703.c27, RN705.7 (R6), U706.13 (B5)
/Expansion/EXP_A12: J701.c26, J702.c26, J703.c26, RN705.6 (R5), U706.14 (B4)
/Expansion/EXP_A13: J701.c25, J702.c25, J703.c25, RN705.5 (R4), U706.15 (B3)
/Expansion/EXP_A14: J701.c24, J702.c24, J703.c24, RN705.4 (R3), U706.16 (B2)
/Expansion/EXP_A15: J701.c23, J702.c23, J703.c23, RN705.3 (R2), U706.17 (B1)
/Expansion/EXP_A16: J701.c22, J702.c22, J703.c22, RN705.2 (R1), U706.18 (B0)
/Expansion/EXP_A17: J701.c21, J702.c21, J703.c21, RN706.9 (R8), U707.11 (B7)
/Expansion/EXP_A18: J701.c20, J702.c20, J703.c20, RN706.8 (R7), U707.12 (B6)
/Expansion/EXP_A19: J701.c19, J702.c19, J703.c19, RN706.7 (R6), U707.13 (B5)
/Expansion/EXP_A20: J701.c18, J702.c18, J703.c18, RN706.6 (R5), U707.14 (B4)
/Expansion/EXP_A21: J701.c17, J702.c17, J703.c17, RN706.5 (R4), U707.15 (B3)
/Expansion/EXP_A22: J701.c16, J702.c16, J703.c16, RN706.4 (R3), U707.16 (B2)
/Expansion/EXP_A23: J701.c15, J702.c15, J703.c15, RN706.3 (R2), U707.17 (B1)
/Expansion/EXP_AM0: J701.b16, J702.b16, J703.b16, RN703.2 (R1), U703.22 (IO9)
/Expansion/EXP_AM1: J701.b17, J702.b17, J703.b17, RN703.3 (R2), U703.21 (IO8)
/Expansion/EXP_AM2: J701.b18, J702.b18, J703.b18, RN703.4 (R3), U703.20 (IO7)
/Expansion/EXP_AM3: J701.b19, J702.b19, J703.b19, RN703.5 (R4), U703.19 (IO6)
/Expansion/EXP_AM4: J701.a23, J702.a23, J703.a23, RN703.6 (R5), U703.18 (IO5)
/Expansion/EXP_AM5: J701.c14, J702.c14, J703.c14, RN703.7 (R6), U703.17 (IO4)
/Expansion/EXP_D0: J701.a1, J702.a1, J703.a1, RN701.2 (R1), U702.2 (A0)
/Expansion/EXP_D1: J701.a2, J702.a2, J703.a2, RN701.3 (R2), U702.3 (A1)
/Expansion/EXP_D2: J701.a3, J702.a3, J703.a3, RN701.4 (R3), U702.4 (A2)
/Expansion/EXP_D3: J701.a4, J702.a4, J703.a4, RN701.5 (R4), U702.5 (A3)
/Expansion/EXP_D4: J701.a5, J702.a5, J703.a5, RN701.6 (R5), U702.6 (A4)
/Expansion/EXP_D5: J701.a6, J702.a6, J703.a6, RN701.7 (R6), U702.7 (A5)
/Expansion/EXP_D6: J701.a8, J702.a8, J703.a8, RN701.8 (R7), U702.8 (A6)
/Expansion/EXP_D7: J701.a7, J702.a7, J703.a7, RN701.9 (R8), U702.9 (A7)
/Expansion/EXP_D8: J701.c1, J702.c1, J703.c1, RN702.2 (R1), U701.2 (A0)
/Expansion/EXP_D9: J701.c2, J702.c2, J703.c2, RN702.3 (R2), U701.3 (A1)
/Expansion/EXP_D10: J701.c3, J702.c3, J703.c3, RN702.4 (R3), U701.4 (A2)
/Expansion/EXP_D11: J701.c4, J702.c4, J703.c4, RN702.5 (R4), U701.5 (A3)
/Expansion/EXP_D12: J701.c5, J702.c5, J703.c5, RN702.6 (R5), U701.6 (A4)
/Expansion/EXP_D13: J701.c6, J702.c6, J703.c6, RN702.7 (R6), U701.7 (A5)
/Expansion/EXP_D14: J701.c7, J702.c7, J703.c7, RN702.8 (R7), U701.8 (A6)
/Expansion/EXP_D15: J701.c8, J702.c8, J703.c8, RN702.9 (R8), U701.9 (A7)
/Expansion/EXP_RnW: J701.a14, J702.a14, J703.a14, RN706.2 (R1), U707.18 (B0)
/Expansion/EXP_VTERM1: C710.1, C711.1, RN701.1 (COM1), RN701.10 (COM2), RN702.1 (COM1), RN702.10 (COM2), RN703.1 (COM1), RN703.10 (COM2), RN707.1 (COM1), RN707.10 (COM2), U708.3, U708.14 (-)
/Expansion/EXP_VTERM2: C712.1, C713.1, RN704.1 (COM1), RN704.10 (COM2), RN705.1 (COM1), RN705.10 (COM2), RN706.1 (COM1), RN706.10 (COM2), U708.5, U708.11 (-)
/Expansion/~EXP_AS: J701.a18, J702.a18, J703.a18, RN707.5 (R4), U704.3
/Expansion/~EXP_BBSY: J701.b1, J702.b1, J703.b1, R705.2
/Expansion/~EXP_BCLR: J701.b2, J702.b2, J703.b2, R706.2
/Expansion/~EXP_BGxIN: J701.b4, J701.b6, J701.b8, J701.b10, J702.b4, J702.b6, J702.b8, J702.b10, J703.b4, J703.b6, J703.b8, J703.b10, R701.2
/Expansion/~EXP_CLK: J701.a10, J702.a10, J703.a10, RN707.2 (R1), U704.11
/Expansion/~EXP_IACKIN: J701.a21, J702.a21, J703.a21, R703.2
/Expansion/~EXP_IACK: J701.a20, J702.a20, J703.a20, R702.2
/Expansion/~EXP_LDS: J701.a13, J702.a13, J703.a13, RN707.4 (R3), U704.8
/Expansion/~EXP_LWORD: J701.c13, J702.c13, J703.c13, R704.2
/Expansion/~EXP_SYSFAIL: J701.c10, J702.c10, J703.c10, R707.2
/Expansion/~EXP_UDS: J701.a12, J702.a12, J703.a12, RN707.3 (R2), U704.6
/Expansion/~VMESEL: U701.19 (CE), U702.19 (CE), U703.23 (IO10), U704.2, U704.5, U704.10, U705.19 (CE), U706.19 (CE), U707.19 (CE)
A1: U705.8 (A6); also elsewhere on the board
A2: U705.7 (A5); also elsewhere on the board
A3: U705.6 (A4); also elsewhere on the board
A4: U705.5 (A3); also elsewhere on the board
A5: U705.4 (A2); also elsewhere on the board
A6: U705.3 (A1); also elsewhere on the board
A7: U705.2 (A0); also elsewhere on the board
A8: U705.9 (A7); also elsewhere on the board
A9: U706.9 (A7); also elsewhere on the board
A10: U706.8 (A6); also elsewhere on the board
A11: U706.7 (A5); also elsewhere on the board
A12: U706.6 (A4); also elsewhere on the board
A13: U706.5 (A3); also elsewhere on the board
A14: U706.4 (A2); also elsewhere on the board
A15: U706.3 (A1); also elsewhere on the board
A16: U706.2 (A0); also elsewhere on the board
A17: U707.9 (A7); also elsewhere on the board
A18: U707.8 (A6); also elsewhere on the board
A19: U707.7 (A5); also elsewhere on the board
A20: U707.6 (A4); also elsewhere on the board
A21: U707.5 (A3); also elsewhere on the board
A22: U707.4 (A2); also elsewhere on the board
A23: U703.5 (I5), U707.3 (A1); also elsewhere on the board
A24: U703.6 (I6); also elsewhere on the board
A25: U703.7 (I7); also elsewhere on the board
CPU_CLK: U704.12, U704.13; also elsewhere on the board
D0: U702.18 (B0); also elsewhere on the board
D1: U702.17 (B1); also elsewhere on the board
D2: U702.16 (B2); also elsewhere on the board
D3: U702.15 (B3); also elsewhere on the board
D4: U702.14 (B4); also elsewhere on the board
D5: U702.13 (B5); also elsewhere on the board
D6: U702.12 (B6); also elsewhere on the board
D7: U702.11 (B7); also elsewhere on the board
D8: U701.18 (B0); also elsewhere on the board
D9: U701.17 (B1); also elsewhere on the board
D10: U701.16 (B2); also elsewhere on the board
D11: U701.15 (B3); also elsewhere on the board
D12: U701.14 (B4); also elsewhere on the board
D13: U701.13 (B5); also elsewhere on the board
D14: U701.12 (B6); also elsewhere on the board
D15: U701.11 (B7); also elsewhere on the board
FC0: U703.8 (I8); also elsewhere on the board
FC1: U703.9 (I9); also elsewhere on the board
FC2: U703.10 (I10); also elsewhere on the board
GND: C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C711.2, C712.2, C713.2, J701.a9, J701.a11, J701.a15, J701.a17, J701.a19, J701.b20, J701.b23, J701.c9, J702.a9, J702.a11, J702.a15, J702.a17, J702.a19, J702.b20, J702.b23, J702.c9, J703.a9, J703.a11, J703.a15, J703.a17, J703.a19, J703.b20, J703.b23, J703.c9, R705.1, R708.2, U701.10 (GND), U702.10 (GND), U703.12 (GND), U704.7 (GND), U705.10 (GND), U706.10 (GND), U707.10 (GND), U708.6 (V-); also elsewhere on the board
unnamed: R708.1, R709.2, U708.12 (+), U708.13 (+)
R/~W: U701.1 (A->B), U702.1 (A->B), U707.2 (A0); also elsewhere on the board
SCL: J701.b21, J702.b21, J703.b21; also elsewhere on the board
SDA: J701.b22, J702.b22, J703.b22; also elsewhere on the board
~AS: U704.1; also elsewhere on the board
~DTACK: J701.a16, J702.a16, J703.a16; also elsewhere on the board
~EXPRAMSEL: U703.11 (I11); also elsewhere on the board
~EXPSEL: U703.1 (I1/CLK); also elsewhere on the board
~EXP_BERR: J701.c11, J702.c11, J703.c11; also elsewhere on the board
~IRQ3: J701.b28, J702.b28, J703.b28, RN707.9 (R8); also elsewhere on the board
~IRQ4: J701.b27, J702.b27, J703.b27, RN707.8 (R7); also elsewhere on the board
~IRQ5: J701.b26, J702.b26, J703.b26, RN707.7 (R6); also elsewhere on the board
~IRQ6: J701.b25, J702.b25, J703.b25, RN707.6 (R5); also elsewhere on the board
~LDS: U704.9; also elsewhere on the board
~RESET: J701.c12, J702.c12, J703.c12; also elsewhere on the board
~UDS: U704.4; also elsewhere on the board

Notes on the sheet:
VME-like, but not VME, if you know what I mean. Address and data lines, GND and voltage rails in the same places. But no fancy stuff. SERCLK and SERDATA pins on the connector are conntected to the I2C SCL and SDA lines. IRQ2 and IRQ1 are both "software interrupts" on this platform, but we'll leave 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
N.B. The system board is "VME slot 0", The Arbitor, and will never grant to any other slot. Similarly, no slot will ever see an IACK cycle. Interrupts will simply be autovectored by the interrupt controller and handled as such by the operating system.
N.B. DS1 = UDS, DS0 = LDS (It's absoultely VITAl to use clear terminology!)
