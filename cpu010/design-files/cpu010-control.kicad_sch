File: cpu010/design-files/cpu010-control.kicad_sch (KiCad schematic)
At the start: 34 parts, among them SW401 SW_DIP_x08, SW402 SW_DIP_x08, U401 DA04-11SURKWA, U402 74HCT273, U403 74HCT273, U404 GAL22V10, U405 74HC245, U406 74HC245, U407 74HCT273, U408 74HC245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

Commit message: Expansion bus changes: - VME bus arb signals are now total no-ops, no daisy-chain. - Ditto for VMS IACK signals. - Neuter some other VME control signals.
Parts:
- removed C408, C409, C410, C411: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C_Small
- removed U409: ATF1504AS-PLCC44, Package_LCC:PLCC-44_THT-Socket, symbol jrt-ICs:ATF1504AS-PLCC44
Connections:
- net ~{BERSEL}: no longer names the net of U404.22 (IO9)
- no-connect marks 16 -> 4

Commit message: More component labeling.
Parts:
- RN401, RN402: Mouser (none) -> 652-4116R-1LF-470
- RN403, RN404: value 3K3 -> 47K; Mouser (none) -> 652-4609X-1LF-47K
- U401: Mouser (none) -> 604-DA04-11SURKWA
- U402, U403, U407: Mouser (none) -> 595-CD74HCT237E
- U404: Mouser (none) -> 556-AF22V10C15PU
- U405, U406, U408: value 74HC245 -> 74HCT245; Mouser (none) -> 595-SN74HCT245NE4
Changed lines of the file:
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@@
 	)
 	(global_label "D13"
-		(shape input)
+		(shape output)
 		(at 227.33 46.99 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D8"
-		(shape input)
+		(shape output)
 		(at 227.33 34.29 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D10"
-		(shape input)
+		(shape output)
 		(at 227.33 39.37 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D2"
-		(shape input)
+		(shape output)
 		(at 227.33 88.9 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D9"
-		(shape input)
+		(shape output)
 		(at 227.33 36.83 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D14"
-		(shape input)
+		(shape output)
 		(at 227.33 49.53 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D4"
-		(shape input)
+		(shape output)
 		(at 227.33 93.98 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D6"
-		(shape input)
+		(shape output)
 		(at 227.33 99.06 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D5"
-		(shape input)
+		(shape output)
 		(at 227.33 96.52 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D0"
-		(shape input)
+		(shape output)
 		(at 227.33 83.82 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D1"
-		(shape input)
+		(shape output)
 		(at 227.33 86.36 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D7"
-		(shape input)
+		(shape output)
 		(at 227.33 101.6 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D12"
-		(shape input)
+		(shape output)
 		(at 227.33 44.45 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D15"
-		(shape input)
+		(shape output)
 		(at 227.33 52.07 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D3"
-		(shape input)
+		(shape output)
 		(at 227.33 91.44 180)
 		(fields_autoplaced yes)
@@
 	)
 	(global_label "D11"
-		(shape input)
+		(shape output)
 		(at 227.33 41.91 180)
 		(fields_autoplaced yes)
@@
 			)
 		)
-		(property "Value" "74HC245"
+		(property "Value" "74HCT245"
 			(at 242.1733 78.74 0)
 			(effects
@@
 			)
 		)
+		(property "Mouser" "595-SN74HCT245NE4"
+			(at 240.03 96.52 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "2"
 		)
@@
 			)
 		)
+		(property "Mouser" "556-AF22V10C15PU"
+			(at 54.61 72.39 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "4"
 		)
@@
 			)
 		)
+		(property "Mouser" "595-CD74HCT237E"
+			(at 109.22 87.63 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "7"
 		)
@@
 			)
 		)
+		(property "Mouser" "652-4116R-1LF-470"
+			(at 129.54 85.09 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "16"
 		)
@@
 			)
 		)
-		(property "Value" "74HC245"
+		(property "Value" "74HCT245"
 			(at 49.1333 172.72 0)
 			(effects
@@
 			)
 		)
+		(property "Mouser" "595-SN74HCT245NE4"
+			(at 46.99 190.5 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "2"
 		)
@@
 			)
 		)
+		(property "Mouser" "604-DA04-11SURKWA"
+			(at 170.18 39.37 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "15"
 		)
@@
 			)
 		)
-		(property "Value" "3K3"
+		(property "Value" "47K"
 			(at 281.94 108.966 90)
 			(effects
@@
 			)
 		)
+		(property "Mouser" "652-4609X-1LF-47K"
+			(at 270.51 109.22 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "3"
 		)
@@
 			)
 		)
+		(property "Mouser" "595-CD74HCT237E"
+			(at 46.99 137.16 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "7"
 		)
@@
 			)
 		)
-		(property "Value" "3K3"
+		(property "Value" "47K"
 			(at 281.94 59.436 90)
 			(effects
@@
 			)
 		)
+		(property "Mouser" "652-4609X-1LF-47K"
+			(at 270.51 59.69 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "3"
 		)
@@
 			)
 		)
+		(property "Mouser" "652-4116R-1LF-470"
+			(at 189.23 85.09 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "16"
 		)
@@
 			)
 		)
+		(property "Mouser" "595-CD74HCT237E"
+			(at 168.91 87.63 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "7"
 		)
@@
 			)
 		)
-		(property "Value" "74HC245"
+		(property "Value" "74HCT245"
 			(at 242.1733 29.21 0)
 			(effects
@@
 			(at 240.03 46.99 0)
 			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Mouser" "595-SN74HCT245NE4"
+			(at 240.03 46.99 0)
+			(effects

Commit message: Add NMI debug button, re-fill zones.
Parts:
- C401, C402, C403, C404, C405, C406, C407, C412, C413, C414, C415, C416, C417, C418, C419, RN401, RN402, RN403, RN404, SW401, SW402, U401, U402, U403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: now left out of the parts list
Changed lines of the file:
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@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)
@@
 		(unit 1)
 		(exclude_from_sim no)
-		(in_bom yes)
+		(in_bom no)
 		(on_board yes)
 		(dnp no)

Commit message: Name / rev / copyright.
Other:
- company: (none) -> (c) 2025, 2026 Jason R. Thorpe.  All rights reserved.
- title: (none) -> 68k Playground CPU010
Changed lines of the file:
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@@
 	(generator_version "9.0")
 	(paper "A3")
+	(title_block
+		(title "68k Playground CPU010")
+		(date "2026-06-08")
+		(rev "A")
+		(company "(c) 2025, 2026 Jason R. Thorpe.  All rights reserved.")
+	)
 	(text "Control space (FC==4):\n[CTLSPDEC]\nxxxx.xxxx xxxx.xxxx 0000.0000 - Diagnostic display (upper digit)\nxxxx.xxxx xxxx.xxxx 0000.0001 - Diagnostic display (lower digit)\nxxxx.xxxx xxxx.xxxx 0001.000x - Configuration switches\nxxxx.xxxx xxxx.xxxx 0010.0000 - System Enable register\n[IOCTL010]\nxxxx.xxxx xxxx.xxxx 0100.0000 - Interrupt Set\nxxxx.xxxx xxxx.xxxx 0101.0000 - Interrupt Clear\n"
 		(exclude_from_sim no)
