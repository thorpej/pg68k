File: cpu010/design-files/cpu010.kicad_pcb (KiCad board)
At the start: 2 copper layers, 223.5 x 132.1 mm, 25 parts, among them U201 MC68010, U301 ATF1508AS, U302 61C3216, U303 74AHCT245, U304 74AHCT245, U305 7C4098, U306 7C4098, U307 74AHCT245, U308 74AHCT245, U309 74AHCT245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

Commit message: Add clock generator.
Parts:
- added U202: 74ACT163, Package_DIP:DIP-16_W7.62mm_Socket, F.Cu at (71.1, 88.9)
- added Y201: 40MHz, Oscillator:Oscillator_DIP-8, F.Cu at (56.2, 100.3)
- U201: value MC68010 -> MC68010P; footprint Package_DIP:DIP-64_W22.86mm -> Package_DIP:DIP-64_W22.86mm_Socket
- U301: value ATF1508AS -> ATF1508AS-TQFP100
Connections:
- U201 pad 14: Net-(U201-V_{CC}-Pad14) -> +5V
- U201 pad 16: Net-(U201-GND-Pad16) -> GND
- U201 pad 49: Net-(U201-V_{CC}-Pad14) -> +5V
- U201 pad 53: Net-(U201-GND-Pad16) -> GND
Other:
- board size 223.5 x 132.1 mm -> 365.8 x 223.5 mm

Commit message: Add a bunch of Control Space stuff.
Parts:
- added RN401: 470R, Package_DIP:DIP-16_W7.62mm_Socket, F.Cu at (88.9, 215.9)
- added RN402: 470R, Package_DIP:DIP-16_W7.62mm_Socket, F.Cu at (114.3, 215.9)
- added RN403: 3K3, Resistor_THT:R_Array_SIP9, F.Cu at (142.2, 218.4)
- added RN404: 3K3, Resistor_THT:R_Array_SIP9, F.Cu at (160.0, 218.4)
- added SW401: SW_DIP_x08, Button_Switch_THT:SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm, F.Cu at (167.6, 223.5)
- added SW402: SW_DIP_x08, Button_Switch_THT:SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm, F.Cu at (193.0, 223.5)
- added U401: DA04-11SURKWA, Display_7Segment:DA04-11SURKWA, F.Cu at (49.6, 234.9)
- added U402: 74HCT273, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (76.2, 215.9)
- added U403: 74HCT273, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (101.6, 215.9)
- added U404: GAL22V10, Package_DIP:DIP-24_W7.62mm_Socket, F.Cu at (81.3, 175.3)
- added U405: 74HC245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (129.5, 215.9)
- added U406: 74HC245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (147.3, 215.9)
- added U407: 74HCT273, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (109.2, 172.7)
- added U408: 74HC245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (96.5, 172.7)
- moved U202 10.5 mm to (61.0, 86.4)
- moved Y201 10.5 mm to (46.0, 97.7)
- moved U304 8.03 mm to (81.3, 137.2)
- moved U303 8.03 mm to (81.3, 106.7)
Other:
- board text added: "0"
- board text added: "15"
- board text added: "Board Control Space Decoding"
- board text added: "Configuration Register"
- board text added: "Diagnostic Display Register"
- board text added: "MMU PageMap (L)"
- board text added: "MMU PageMap (U)"
- board text added: "MMU PageMap Entry (L) Transceivers"
- board text added: "MMU PageMap Entry (U) Transceivers"
- board text added: "MMU PageMap Index Latch"
- board text added: "MMU PageMap Index Mux"
- board text added: "MMU SegMap"
- board text added: "MMU SegMap Entry Transceivers"
- board text added: "System Enable Register"
- board text removed: "PageMap Index Latch"
- board text removed: "PageMap Index Mux"
- board text removed: "PageMap(L)"
- board text removed: "PageMap(L) Entry Transceivers"
- board text removed: "PageMap(U)"
- board text removed: "PageMap(U) Entry Transceivers"
- board text removed: "SegMap"
- board text removed: "SegMap Entry Transceivers"

Commit message: Wire up Bus Error register.
Parts:
- added U409: ATF1504AS-PLCC44, Package_LCC:PLCC-44_THT-Socket, F.Cu at (109.2, 177.8)
- moved U407 50.8 mm to (160.0, 174.2)
- moved U408 48.3 mm to (144.8, 174.2)
- moved U307 10.2 mm to (144.8, 104.1)
- moved U308 10.2 mm to (144.8, 134.6)
- moved U309 10.2 mm to (160.0, 104.1)
- moved U310 10.2 mm to (160.0, 134.6)
- moved U303 2.54 mm to (81.3, 104.1)
- moved U304 2.54 mm to (81.3, 134.6)
- moved U404 2.54 mm to (81.3, 172.7)
Connections:
- U201 pad 18: unconnected-(U201-~{RESET}-Pad18) -> ~{RESET}
- U201 pad 22: unconnected-(U201-~{BERR}-Pad22) -> ~{CPU_BERR}
Other:
- board text added: "Bus Error Controller"

Commit message: Fix up the Enable register.
Connections:
- U301 pad 2: MMU_FAULT -> unconnected-(U301-I/O-Pad2)
- U301 pad 28: unconnected-(U301-I/O-Pad28) -> MMUERR0
- U301 pad 29: unconnected-(U301-I/O-Pad29) -> MMUERR1
- U301 pad 30: unconnected-(U301-I/O-Pad30) -> MMUERR2
- U407 pad 12: unconnected-(U407-Q4-Pad12) -> Net-(U407-Q4)
- U407 pad 13: Net-(U407-D4) -> D12
- U407 pad 14: Net-(U407-D5) -> D13
- U407 pad 15: unconnected-(U407-Q5-Pad15) -> Net-(U407-Q5)
- U407 pad 16: unconnected-(U407-Q6-Pad16) -> Net-(U407-Q6)
- U407 pad 17: Net-(U407-D6) -> D14
- U407 pad 18: Net-(U407-D7) -> D15
- U407 pad 19: unconnected-(U407-Q7-Pad19) -> Net-(U407-Q7)
- U407 pad 3: Net-(U407-D0) -> D8
- U407 pad 4: Net-(U407-D1) -> D9
- U407 pad 5: unconnected-(U407-Q1-Pad5) -> Net-(U407-Q1)
- U407 pad 6: unconnected-(U407-Q2-Pad6) -> Net-(U407-Q2)
- U407 pad 7: Net-(U407-D2) -> D10
- U407 pad 8: Net-(U407-D3) -> D11
- U407 pad 9: unconnected-(U407-Q3-Pad9) -> Net-(U407-Q3)
- U408 pad 1: /Control Space/~{ERRD} -> GND
- U408 pad 11: Net-(U407-D7) -> D15
- U408 pad 12: Net-(U407-D6) -> D14
- U408 pad 13: Net-(U407-D5) -> D13
- U408 pad 14: Net-(U407-D4) -> D12
- U408 pad 15: Net-(U407-D3) -> D11
- U408 pad 16: Net-(U407-D2) -> D10
- U408 pad 17: Net-(U407-D1) -> D9
- U408 pad 18: Net-(U407-D0) -> D8
- U408 pad 19: GND -> /Control Space/~{ERRD}
- U408 pad 2: D8 -> MMU_EN
- U408 pad 3: D9 -> Net-(U407-Q1)
- U408 pad 4: D10 -> Net-(U407-Q2)
- U408 pad 5: D11 -> Net-(U407-Q3)
- U408 pad 6: D12 -> Net-(U407-Q4)
- U408 pad 7: D13 -> Net-(U407-Q5)
- U408 pad 8: D14 -> Net-(U407-Q6)
- U408 pad 9: D15 -> Net-(U407-Q7)
- U409 pad 11: unconnected-(U409-I/O/PD1-Pad11) -> D10
- U409 pad 12: unconnected-(U409-I/O-Pad12) -> D11
- U409 pad 14: unconnected-(U409-I/O-Pad14) -> D12
- U409 pad 16: unconnected-(U409-I/O-Pad16) -> D13
- U409 pad 17: unconnected-(U409-I/O-Pad17) -> D14
- U409 pad 18: unconnected-(U409-I/O-Pad18) -> D15
- U409 pad 19: unconnected-(U409-I/O-Pad19) -> MMUERR0
- U409 pad 20: unconnected-(U409-I/O-Pad20) -> MMUERR1
- U409 pad 21: unconnected-(U409-I/O-Pad21) -> MMUERR2
- U409 pad 4: CLK10 -> ~{CPU_BERR}
- U409 pad 5: unconnected-(U409-I/O-Pad5) -> BERR_DTACK
- U409 pad 6: unconnected-(U409-I/O-Pad6) -> R/~{W}
- U409 pad 8: unconnected-(U409-I/O-Pad8) -> D8
- U409 pad 9: unconnected-(U409-I/O-Pad9) -> D9

Commit message: Add top-level address decoding.
Parts:
- added U101: GAL22V10, Package_DIP:DIP-24_W7.62mm_Socket, F.Cu at (228.6, 170.2)
- moved U323 40.6 mm to (228.6, 104.1)
- moved U324 40.6 mm to (228.6, 134.6)
Connections:
- net /MMU/~{LDS} renamed ~{LDS}
- net /MMU/~{UDS} renamed ~{UDS}
- U301 pad 76: /MMU/~{AS} -> ~{AS}
- U408 pad 11: D15 -> Net-(U407-Q7)
- U408 pad 12: D14 -> Net-(U407-Q6)
- U408 pad 13: D13 -> Net-(U407-Q5)
- U408 pad 14: D12 -> Net-(U407-Q4)
- U408 pad 15: D11 -> Net-(U407-Q3)
- U408 pad 16: D10 -> Net-(U407-Q2)
- U408 pad 17: D9 -> Net-(U407-Q1)
- U408 pad 18: D8 -> MMU_EN
- U408 pad 2: MMU_EN -> D8
- U408 pad 3: Net-(U407-Q1) -> D9
- U408 pad 4: Net-(U407-Q2) -> D10
- U408 pad 5: Net-(U407-Q3) -> D11
- U408 pad 6: Net-(U407-Q4) -> D12
- U408 pad 7: Net-(U407-Q5) -> D13
- U408 pad 8: Net-(U407-Q6) -> D14
- U408 pad 9: Net-(U407-Q7) -> D15
Other:
- board text added: "Top-level Address Decoding"

Commit message: On-board memory (RAM + ROM).
Parts:
- added U501: GAL22V10, Package_DIP:DIP-24_W7.62mm_Socket, F.Cu at (228.6, 210.8)
- added U502: CY62158, Package_SO:TSOP-II-44_10.16x18.41mm_P0.8mm, F.Cu at (251.5, 195.5)
- added U503: CY62158, Package_SO:TSOP-II-44_10.16x18.41mm_P0.8mm, F.Cu at (271.3, 195.5)
- added U504: CY62158, Package_SO:TSOP-II-44_10.16x18.41mm_P0.8mm, F.Cu at (251.5, 223.5)
- added U505: CY62158, Package_SO:TSOP-II-44_10.16x18.41mm_P0.8mm, F.Cu at (271.8, 223.5)
- added U506: SST39SF040, Package_DIP:DIP-32_W15.24mm_Socket, F.Cu at (246.4, 133.3)
- added U507: SST39SF040, Package_DIP:DIP-32_W15.24mm_Socket, F.Cu at (266.7, 133.3)
Other:
- board text added: "(Lower byte)"
- board text added: "(Lower word)"
- board text added: "(Upper byte)"
- board text added: "(Upper word)"
- board text added: "4MB RAM"
- board text added: "On-board Memory Interface Logic"
- board text added: "System ROM"

Commit message: Open-drain inverter for DTACKs.
Parts:
- added R201: 0R, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, F.Cu at (116.8, 174.0)
- added R202: 0R, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, F.Cu at (116.8, 163.8)
- added R203: 0R, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, F.Cu at (99.1, 163.8)
- added U203: 74ACT05, Package_DIP:DIP-14_W7.62mm_Socket, F.Cu at (104.1, 157.5)
- moved U302 11.2 mm to (106.7, 136.1)
- moved U301 10.2 mm to (109.2, 106.7)
- moved U409 6.35 mm to (109.2, 184.2)
Connections:
- U404 pad 23: ~{DTACK} -> CTLSP_DTACK
