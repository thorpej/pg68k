File: cpu030/design-files/cpu030.kicad_pcb (KiCad board)
At the start: 4 copper layers, 259.9 x 154.9 mm, 132 parts, among them J101 Reset, J102 SYSCTL JTAG, J103 NMI, J201 DRAM0SZ, J202 DRAM0 JTAG, J301 UART1 FTDI, J302 UART0 FTDI, J303 UART0, J304 UART1, J401 ISACTL JTAG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

Commit message: Add some silk screen describing the UART connector pinning.
Other:
- board text added: "GND CTS (NC) TxD RxD RTS <-- FTDI GND RTS (NC) RxD TxD CTS <-- UART"
Changed lines of the file:
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@@
+		)
+	)
+	(gr_text "GND CTS (NC) TxD RxD RTS <-- FTDI\nGND RTS (NC) RxD TxD CTS <-- UART"
+		(at 199.5932 91.0844 0)
+		(layer "F.SilkS")
+		(effects
+			(font
+				(size 1 1)
+				(thickness 0.125)
+			)
+			(justify left bottom)
 		)
 	)

Commit message: Silk screen with the system name.
Other:
- board text added: "Made by @thorpej"
- board text added: "Playground 68030 Mk I"
- board text added: "https://github.com/thorpej/pg68k"

Commit message: Silk screen for board rev.
Other:
- board text added: "Rev A"

Commit message: Add I2C controller and RTC.
Parts:
- added BT601: CR1220, Battery:BatteryHolder_Keystone_500, F.Cu at (248.5, 103.2)
- added C601: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (242.0, 105.2)
- added C602: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (230.9, 97.0)
- added R601: 4K7, Resistor_SMD:R_0805_2012Metric, F.Cu at (229.3, 112.7)
- added R602: 4K7, Resistor_SMD:R_0805_2012Metric, F.Cu at (228.5, 106.7)
- added R603: 4K7, Resistor_SMD:R_0805_2012Metric, F.Cu at (228.5, 109.3)
- added U601: PCF8584, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (231.8, 104.2)
- added U602: DS3231MZ, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (235.6, 96.6)

Commit message: Add Ethernet.
Parts:
- added C701: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (244.5, 113.6)
- added C702: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (278.0, 107.9)
- added C703: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (268.9, 107.9)
- added C704: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (256.8, 122.4)
- added C705: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (265.3, 129.2)
- added C706: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (273.7, 129.2)
- added C707: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (284.1, 121.7)
- added C708: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (298.1, 115.0)
- added C709: 10nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (283.2, 105.0)
- added C710: 10nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (263.9, 102.6)
- added J701: RJ45_Amphenol_RJMG1BD3B8K1ANR, Connector_RJ:RJ45_Amphenol_RJMG1BD3B8K1ANR, F.Cu at (278.0, 101.6)
- added R701: 10K, Resistor_SMD:R_0805_2012Metric, F.Cu at (284.1, 113.7)
- added R702: 10K, Resistor_SMD:R_0805_2012Metric, F.Cu at (270.5, 129.2)
- added R703: 470, Resistor_SMD:R_0805_2012Metric, F.Cu at (263.9, 92.8)
- added R704: 470, Resistor_SMD:R_0805_2012Metric, F.Cu at (283.3, 91.2)
- added U701: RTL8019AS, Package_QFP:PQFP-100_14x20mm_P0.65mm, F.Cu at (270.8, 118.2)
- added U702: AT93C46D-PU, Package_DIP:DIP-8_W7.62mm_Socket, F.Cu at (287.9, 114.1)
- added Y701: 20MHz, Oscillator:Oscillator_DIP-8, F.Cu at (244.6, 125.8)
Connections:
- J501 pad 27: ISA_IORDY -> ISA_RDY

Commit message: Checkpoint -- expansion interface and PSU placeholders.  More work to do, but I want to get mounting holes placed.
Parts:
- added C801: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (110.1, 194.0)
- added C802: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (110.1, 165.1)
- added C803: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (110.1, 136.2)
- added C804: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (122.8, 136.2)
- added C805: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (122.8, 194.0)
- added C806: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (122.8, 165.1)
- added C807: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (135.6, 194.1)
- added C808: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (135.6, 165.1)
- added C809: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (135.6, 136.3)
- added H101: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (342.1, 88.4)
- added H102: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (342.1, 235.2)
- added H103: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (90.4, 88.4)
- added H104: MountingHole, MountingHole:MountingHole_3.2mm_M3, F.Cu at (90.4, 235.2)
- added J801: DIN41612_03x32_ABC, Connector_DIN:DIN41612_R_3x32_Female_Horizontal_THT, F.Cu at (91.6, 214.9)
- added J901: ATX-24, Connector_Molex:Molex_Mini-Fit_Jr_5569-24A1_2x12_P4.20mm_Horizontal, F.Cu at (332.2, 177.0)
- added R404: 3K3, Resistor_SMD:R_0805_2012Metric, F.Cu at (203.0, 108.2)
- added R405: 3K3, Resistor_SMD:R_0805_2012Metric, F.Cu at (206.4, 108.2)
- added U801: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (99.9, 193.1)
- added U802: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (99.9, 164.2)
- added U803: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (99.9, 135.3)
- added U804: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (112.6, 135.3)
- added U805: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (112.6, 193.1)
- added U806: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (112.6, 164.2)
- added U807: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (125.4, 193.1)
- added U808: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (125.4, 164.2)
- added U809: 74ACT245, Package_DIP:DIP-20_W7.62mm_Socket, F.Cu at (125.4, 135.3)
- R503: value 330 -> 470
- moved J501 38.8 mm to (143.6, 100.4), turned to -90 degrees
- moved C502 33.6 mm to (150.2, 130.2), turned to -90 degrees
- moved U501 32.9 mm to (147.6, 110.7), turned to -90 degrees
- moved C501 32.3 mm to (150.2, 119.2), turned to -90 degrees
- moved U502 28.2 mm to (147.6, 121.6), turned to -90 degrees
- moved U503 25.6 mm to (114.2, 110.7), turned to -90 degrees
- moved C503 15.6 mm to (117.6, 118.3), turned to 0 degrees
- moved R501 12.2 mm to (119.4, 120.3), turned to 180 degrees
- moved R502 11.8 mm to (119.4, 123.6), turned to 180 degrees
Connections:
- D101 pad 1: +5V -> PWR_OK
- J501 pad 32: unconnected-(J501-Pin_32-Pad32) -> ~{ISA_IO16}
- R101 pad 1: +5V -> PWR_OK
- R701 pad 2: Net-(U701-~{IOCS16B/SLOT16}) -> Net-(U701-~{SMEMRB})
- U401 pad 83: unconnected-(U401-I/O-Pad83) -> ~{ISA_IO16}
- U701 pad 31: +5V -> Net-(U701-~{SMEMRB})
- U701 pad 32: +5V -> Net-(U701-~{SMEMRB})
- U701 pad 96: Net-(U701-~{IOCS16B/SLOT16}) -> ~{ISA_IO16}
