# Repository thorpej/pg68k

File README.md:

# pg68k
The 68k Playground, a 680x0-based home-brew computer with multiple CPU options

This is a series of home-brew computers based on the Motorola 680x0 family
of CPUs.  I intend to build at least a few different flavors, ranging from
a 68000-based BASIC machine to (eventually, one of these days, maybe) a
68060-based workstation.  As a person who has spent his entire career doing
system software, this is a vehicle to learn hardware design.

The first machine in the series is the [Phaethon 1](cpu010/README.md).

## KiCad design nqvme_template/design-files/nqvme_template.kicad_pcb

File nqvme_template/README.md:

# NQVME Expansion Boards

These expansion boards are desgined to be simple and self-identifying,
not quite plug-and-play, but pretty close.

The 16MB VME address space is divided up into 8 2MB regions.  Each
board is configured to start at one of these regions (for boards
that fit within 2MB, a 3-bit DIP switch is perfect).  That switch
can be used with a 74HCT688 8-bit comparator, but also configures
the address of a 128 byte AT24C01 I2C EEPROM.  This EEPROM contains
a binary data blob structured like so:

    // all fields big-endian
    struct nqvme_reg {
        uint32_t  offset;
	uint32_t  size;
	uint32_t  flags;
    };

    #define REG_F_REGSHIFT        0x01 // reg-shift == 1
    #define REG_F_ONLY16          0x02 // only 16-bit cycles allowed
    #define REG_F_WTCACHE         0x04 // write-through cacheable
    // all other flags reserved

    struct nqvme_exphdr {
        uint8_t   magic[12];           // pg68k,nqvme\0
        uint8_t   compat[32];          // NUL-terminated, padded string
        struct nqvme_reg regs[4];      // device regions (size==0 terminates)
        uint8_t   irqs[4];             // interrupts used (irq=0 terminates)
        uint8_t   reserved[28];        // reserved for future expansion
	uint32_t  cksum;               // 32-bit xor checksum of struct
    };

The firmware will probe for valid EEPROMs, and based on which EEPROMs
respond, will compute the physical addresses of each board and construct
device-tree entries for the OS kernel; the OS kernel need not know anything
about the EEPROM format.

Parts:
C201, C202, C203: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J201: DIN41612_03x32_ABC; DIN41612_C_3x32_Male_Horizontal_THT
R201: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW201: SW_DIP_x03; SW_DIP_SPSTx03_Slide_9.78x9.8mm_W7.62mm_P2.54mm
U201: AT24C01; DIP-8_W7.62mm_Socket
U202: CD74HCT688M96; SOIC-20W_7.5x12.8mm_P1.27mm
U203: GAL22V10; DIP-24_W7.62mm_Socket

Connections:
+5V: C201.1, C202.1, C203.1, J201.a32, J201.b32, J201.c32, R201.2, U201.7 (~WC), U201.8 (VCC), U202.20 (VCC), U203.24 (VCC)
+5Vsb: J201.b31
+12V: J201.c31
-12V: J201.a31
/NQVME interface/A21M: SW201.3, U201.1 (E0), U202.14 (R5)
/NQVME interface/A22M: SW201.2, U201.2 (E1), U202.16 (R6)
/NQVME interface/A23M: SW201.1, U201.3 (E2), U202.18 (R7)
/NQVME interface/~RMATCH: U202.19 (P=R), U203.1 (I1/CLK)
A1: J201.a30
A2: J201.a29
A3: J201.a28
A4: J201.a27
A5: J201.a26
A6: J201.a25
A7: J201.a24
A8: J201.c30
A9: J201.c29
A10: J201.c28
A11: J201.c27
A12: J201.c26
A13: J201.c25
A14: J201.c24
A15: J201.c23
A16: J201.c22
A17: J201.c21
A18: J201.c20
A19: J201.c19
A20: J201.c18
A21: J201.c17, U202.13 (P5)
A22: J201.c16, U202.15 (P6)
A23: J201.c15, U202.17 (P7)
AM0: J201.b16, U203.10 (I10)
AM1: J201.b17, U203.9 (I9)
AM2: J201.b18, U203.8 (I8)
AM3: J201.b19, U203.7 (I7)
AM4: J201.a23, U203.6 (I6)
AM5: J201.c14, U203.11 (I11)
D0: J201.a1
D1: J201.a2
D2: J201.a3
D3: J201.a4
D4: J201.a5
D5: J201.a6
D6: J201.a7
D7: J201.a8
D8: J201.c1
D9: J201.c2
D10: J201.c3
D11: J201.c4
D12: J201.c5
D13: J201.c6
D14: J201.c7
D15: J201.c8
GND: C201.2, C202.2, C203.2, J201.a9, J201.a11, J201.a15, J201.a17, J201.a19, J201.b20, J201.b23, J201.c9, U201.4 (VSS), U202.1 (G), U202.2 (P0), U202.3 (R0), U202.4 (P1), U202.5 (R1), U202.6 (P2), U202.7 (R2), U202.8 (P3), U202.9 (R3), U202.10 (GND), U202.11 (P4), U202.12 (R4), U203.12 (GND)
unnamed: R201.1, SW201.4, SW201.5, SW201.6
R/~W: J201.a14, U203.3 (I3)
SCL: J201.b21, U201.5 (SDA)
SDA: J201.b22, U201.6 (SCL)
SYSCLK: J201.a10
~AS: J201.a18, U203.13 (I12)
~BERR: J201.c11
~DTACK: J201.a16
~IRQ3: J201.b28
~IRQ4: J201.b27
~IRQ5: J201.b26
~IRQ6: J201.b25
~LDS: J201.a13, U203.4 (I4)
~RESET: J201.c12
~UDS: J201.a12, U203.5 (I5)
~VMEAS: U203.23 (IO10)

Board: 4 copper layers, 9 parts (0 on the bottom side), 22 nets, no tracks yet.

## KiCad design cpu010/design-files/cpu010.kicad_pcb

File cpu010/README.md (part):

# Phaethon 1 - a 68010-based Unix machine

The Phaethon 1 (pg68010 Mk I) is a 68010-based Unix-capable computer,
loosely inspired by the Sun 2 workstations.  It was specifically
designed with the NetBSD operating system in mind, but Linux and
older Unix SVR3 releases would be possible, as well.

The Phaethon 1 is named for the son of Helios, the Sun god, who crashed
the chariot because he didn't know what he was doing.  Why did I choose
to make a Unix machine with a 68010?  Because it gave me the opportunity
(actually, it forced me) to design an MMU capable of demand-paged virtual
memory, something I've long wanted to do.

The heart of the Phaethon 1 is the MMU, or Memory Management Unit.  All
regular (User/Supervisor Program/Data, Function Codes 1, 2, 5, and 6)
bus cycles are controlled by the MMU, and except for the earliest
bootstrap stages controlled by the firmware, the MMU must be enabled
in order for the system to function at all.  Every address generated
by the CPU for the four relevant FCs is treated as a virtual address;
physical addresses exist only on the downstream side of the MMU.  On
the upstream (CPU) side of the MMU, address lines are referred to as
VA[1..23], and on the downstream side, address lines are referred to
as A[1..27].

The overall architecture of the system is fairly simple.  The system
has a 28-bit (256MB) physical address space that is mapped by the MMU
into the 68010's 24-bit (16MB) addressing capability.  This 28 bit
physical address space is divided up into four 64MB regions, selected
by bits 26 and 27 of the address:

* 00 -- RAM (on-board and expansion)
* 01 -- ROM (system firmware)
* 10 -- on-board I/O devices
* 11 -- expansion I/O ("not quite VME")

In order to keep things simple, only the CPU can master the bus.
None of the I/O devices on the Phaethon 1 have DMA capability.

In addition to the 4 physical address regions, the Phaethon 1 has a
"control space" selected by FC 4.  This space, accessible using the
`MOVES` instruction, is where the MMU resides, in addition to some
configuration registers and a diagnostic display register.

## The RAM region

The RAM subsystem is very simple.  There is 8MB of SRAM on the system
board at physical address $0000.0000, arranged as 4 banks of 2MB each,
each bank having a 1MB SRAM chip attached to each of the 2 68010 byte
lanes (upper and lower).

Memory address decoding and strobe logic is handled by an ATF1504AS
PLCC44 CPLD programmed with [memctl010](cpld-files/memctl010.v).
This CPLD also performs this function for the ROM region, which is
described in the next section.

A[25:23] == 0 selects the on-board RAM.  For all other values of
A[25:23], expansion RAM is selected.  When expansion RAM is selected,
the [vmeglue](gal-files/vmeglue.gal) GAL sets the VMEbus Address
Modifier to a value in the range of `$11` to `$1f`, with the lower
3 bits being taken from A[25:23], thus allowing expansion RAM to
phyically reside on the nqVME bus without occupying nqVME address
space.

## The ROM region

The ROM region is comprised of a pair of 512KB flash ROM chips,
each connected to one of the 68010 byte lanes, thus providing 1MB
of system ROM.  Address decoding and strobe logic for the ROM is
handled by the same CPLD that handles those duties for the RAM
region.

A key difference in the ROM case is that all regular bus cycles
select the ROM when the MMU is disabled.  The system ROM is linked
at address $F00000, but when the MMU is off even absolute
references will work during early bootstrap.  Operating in this
way facilitates having the vector table at the correct location
when the CPU comes out of reset.  Note that this means that the
stack and all I/O devices are inaccessible by the system firmware
until it has bootstrapped virtual memory and enabled the MMU.

## The on-board I/O region

The on-board I/O region consists of the following:

* A TL16C2552 dual-UART, port B at $800.0000 ("uart0") and
port A at $800.0100 ("uart1").  This arrangement is due to
the on-board address decoding of the TL16C2552.
* A system timer (integrated into the I/O controller) at
$800.0200.
* A PCF8584 I2C controller at $800.0300.
* An ATA disk interface at $800.0400 (CS1FX-, command) and
$800.0410 (CS3FX-, control).

Note that all of on-board I/O devices can be mapped with a
single 4KB virtual page.  The on-board I/O space is also
incompletely-decoded, and will repeat every 4KB.

The [ioctl010](cpld-files/ioctl010.v) I/O controller, implemented
in an ATF1508AS TQFP100 CPLD, performs the following functions:

* Address decoding and selection logic for the on-board
peripherals.
* Bus cycle state machine for the on-board peripherals.
* Implements a 16-bit count-down timer running at 1/16th the
CPU clock frequency, intended for use as the system timer
by the operating system.
* An interrupt controller.

### System timer

The system timer is a basic 16-bit count-down timer that counts
at 1/16th the CPU clock frequency.  It is specifically designed
to be used as the "hardclock" timer that drives scheduling and
time-keeping in the Unix operating system, and the interface to
the timer was designed for maximum convenience for that purpose.

The interface to the timer is via 3 8-bit registers:

* _Timer_CSR_ - control and status register, comprised of a
read-write _Enable_ bit and a read-only _Pending_ bit.
* _Timer_LSB_ - timer count least-significant byte
* _Timer_MSB_ - timer count most-significant byte

The general flow for using the system timer is as follows:

* Determine the number of ticks required for the desired clock
rate.  This value must be in the range of 1-65535.
* Program the tick count into the _Timer_LSB_ and _Timer_MSB_
registers.  The order in which these registers are programmed
does not matter, and writing to either of them implicitly
disables the timer, so no spurious timer expirations will
occur.
* Enable the timer by setting the _Enable_ bit in the
_Timer_CSR_ register.

The timer will now interrupt at the period selected by the
programmed tick count.  When the timer expires, the programmed
value is automatically re-loaded so that any delay in servicing
the timer interrupt will not result in clock skew.  The interrupt
is level-sensitive and the interrupt handler must acknowledge the
interrupt by reading _Timer_CSR_.  Software may also poll for
timer expiration by reading the _Pending_ bit in _Timer_CSR_.  This
can be used, for example, to calibrate a divisor for a software
`delay()` function.

### Interrupt controller

The interrupt controller is a simple priority encoder that takes
the the various interrupt inputs and encodes them to a 68010
interrupt priority level 1-7.  After encoding the interrupt
priority for the CPU and placing the value into the 68010's
IPL[0..2] inputs, the interrupt controller responds to interrupt
acknowledge cycles from the CPU by assertint it's `/AVEC` output
which indicates to the 68010 that the interrupt should be
auto-vectored.  On the Phaethon 1, `/AVEC` is connected to the
CPU's `/VPA` input because auto-vectored interrupts were a key
component of the 6800 peripheral interface on the 68000 and
68010.

The interrupts for the on-board peripherals are hard-wired in
the interrupt controller for maximum convenience for a
Unix-like operating system:

* The system timer interrupts at IPL 6.
* The UARTs interrupt at IPL 5.
* The I2C controller interrupts at IPL 5.
* The ATA disk interface interrupts at IPL 3.

In addition to the on-board peripheral interrupt sources, 5
external interrupts are provided, IRQ[3..7].  These are
active-low level-sensitive inputs intended to be driven by
open-drain interrupt outputs, which facilitates a wired-OR
shared interrupt system.

In addition to these external interrupt inputs, there is a
software-controlled interrupt mechanism.  This consists of
two registers in the Phaethon 1 control space that allow
IPLs 1 and 2 to be asserted and negated by software.  This
will be discussed further in the section describing control
space.

Parts:
H101, H102, H103, H104, H105, H106, H107, H108, H109, H110, H111, H112: MountingHole; MountingHole_3.2mm_M3
J101: JTAG; PinHeader_2x05_P2.54mm_Vertical
R101, R102, R103: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+5V: J101.4, R101.2, R102.2, R103.2; also elsewhere on the board
GND: J101.2, J101.10; also elsewhere on the board
MMU_TDI: J101.9, R103.1; also elsewhere on the board
TCK: J101.1, R101.1; also elsewhere on the board
TDO: J101.3; also elsewhere on the board
TMS: J101.5, R102.1; also elsewhere on the board

Notes on the sheet:
Top-level physical address map: 00xx xxxx.xxxx xxxx.xxxx xxxx.xxxx - RAM 01xx xxxx.xxxx xxxx.xxxx xxxx.xxxx - ROM 10xx xxxx.xxxx xxxx.xxxx xxxx.xxxx - On-board I/O 11xx xxxx.xxxx xxxx.xxxx xxxx.xxxx - (NQ)VME I/O Control space (FC==4): xxxx.xxxx xxxx.xxxx xxxx.000x - see Control Space sheet xxxx.xx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
JTAG Chain: MMU (1508) -> IOCTL (1508) -> MEMCTL (1504)

Parts:
C201, C206: 100µF; CP_Radial_D6.3mm_P2.50mm; Part Wurth 860040373002; Mouser 710-860040373002
C202, C203, C204, C205: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D201: BAT86,113; D_DO-35_SOD27_P7.62mm_Horizontal; Part Nexperia BAT86,113; Mouser 771-BAT86113
D202: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
R201: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R202, R203: 0R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R204, R205: 3K3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R206, R207, R208, R209, R211, R212: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R210: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN201, RN202: 47K; R_Array_SIP9; Mouser 652-4609X-1LF-47K
SW201: Reset; SW_PUSH_6mm
U201: MC68010; DIP-64_W22.86mm_Socket
U202: 74ACT05; DIP-14_W7.62mm_Socket; Mouser 595-CD74ACT05E
U203: DS1813; TO-92_Inline; Mouser 700-DS1813-5+
Y201: 40MHz; Oscillator_DIP-8; Part CTS MXO45HST-3C-40M0000; Mouser 774-MXO45HST-3C-40.0

Connections:
+5V: C202.1, C203.1, C204.1, C205.1, C206.1, R201.1, R205.1, R206.2, R207.2, R208.2, R209.1, R211.2, R212.2, RN201.1 (common), RN202.1 (common), U201.14 (V_{CC}), U201.49 (V_{CC}), U202.14 (VCC), Y201.1 (EN), Y201.8 (Vcc); also elsewhere on the board
CLK40: R210.2; also elsewhere on the board
CPU_CLK: U201.15 (CLK); also elsewhere on the board
CTLSP_DTACK: U202.5; also elsewhere on the board
D0: RN201.6 (R5), U201.5 (D0); also elsewhere on the board
D1: RN201.5 (R4), U201.4 (D1); also elsewhere on the board
D2: RN201.4 (R3), U201.3 (D2); also elsewhere on the board
D3: RN201.3 (R2), U201.2 (D3); also elsewhere on the board
D4: RN201.2 (R1), U201.1 (D4); also elsewhere on the board
D5: RN202.2 (R1), U201.64 (D5); also elsewhere on the board
D6: RN202.3 (R2), U201.63 (D6); also elsewhere on the board
D7: RN202.4 (R3), U201.62 (D7); also elsewhere on the board
D8: RN202.5 (R4), U201.61 (D8); also elsewhere on the board
D9: RN202.6 (R5), U201.60 (D9); also elsewhere on the board
D10: RN202.7 (R6), U201.59 (D10); also elsewhere on the board
D11: RN202.8 (R7), U201.58 (D11); also elsewhere on the board
D12: RN202.9 (R8), U201.57 (D12); also elsewhere on the board
D13: RN201.7 (R6), U201.56 (D13); also elsewhere on the board
D14: RN201.8 (R7), U201.55 (D14); also elsewhere on the board
D15: RN201.9 (R8), U201.54 (D15); also elsewhere on the board
FC0: U201.28 (FC0); also elsewhere on the board
FC1: U201.27 (FC1); also elsewhere on the board
FC2: U201.26 (FC2); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, R202.1, R203.1, SW201.2, U201.16 (GND), U201.53 (GND), U202.7 (GND), U203.3 (GND), Y201.4 (GND); also elsewhere on the board
IOCTL_DTACK: U202.9; also elsewhere on the board
IPL0: R206.1, U201.25 (~IPL0); also elsewhere on the board
IPL1: R207.1, U201.24 (~IPL1); also elsewhere on the board
IPL2: R208.1, U201.23 (~IPL2); also elsewhere on the board
MMU_DTACK: U202.1; also elsewhere on the board
unnamed: C201.1, D202.2 (A), R204.2, U203.2 (Vcc)
unnamed: R202.2, U202.11
unnamed: R203.2, U202.13
unnamed: R209.2, U201.12 (~BGACK), U201.13 (~BR)
unnamed: R210.1, Y201.5 (OUT)
OBMEM_DTACK: U202.3; also elsewhere on the board
PWR_OK: D202.1 (K), R204.1; also elsewhere on the board
R/~W: U201.9 (R/~W); also elsewhere on the board
VA1: U201.29 (A1); also elsewhere on the board
VA2: U201.30 (A2); also elsewhere on the board
VA3: U201.31 (A3); also elsewhere on the board
VA4: U201.32 (A4); also elsewhere on the board
VA5: U201.33 (A5); also elsewhere on the board
VA6: U201.34 (A6); also elsewhere on the board
VA7: U201.35 (A7); also elsewhere on the board
VA8: U201.36 (A8); also elsewhere on the board
VA9: U201.37 (A9); also elsewhere on the board
VA10: U201.38 (A10); also elsewhere on the board
VA11: U201.39 (A11); also elsewhere on the board
VA12: U201.40 (A12); also elsewhere on the board
VA13: U201.41 (A13); also elsewhere on the board
VA14: U201.42 (A14); also elsewhere on the board
VA15: U201.43 (A15); also elsewhere on the board
VA16: U201.44 (A16); also elsewhere on the board
VA17: U201.45 (A17); also elsewhere on the board
VA18: U201.46 (A18); also elsewhere on the board
VA19: U201.47 (A19); also elsewhere on the board
VA20: U201.48 (A20); also elsewhere on the board
VA21: U201.50 (A21); also elsewhere on the board
VA22: U201.51 (A22); also elsewhere on the board
VA23: U201.52 (A23); also elsewhere on the board
~CPU_AS: U201.6 (~AS); also elsewhere on the board
~CPU_BERR: R211.1, U201.22 (~BERR); also elsewhere on the board
~CPU_LDS: U201.8 (~LDS); also elsewhere on the board
~CPU_UDS: U201.7 (~UDS); also elsewhere on the board
~DTACK: R201.2, U201.10 (~DTACK), U202.2, U202.4, U202.6, U202.8; also elsewhere on the board
~HALT: D201.1 (K), SW201.1, U201.17 (~HALT), U203.1 (~RST)
~RESET: D201.2 (A), R205.2, U201.18 (~RESET); also elsewhere on the board
~VPA: R212.1, U201.21 (~VPA); also elsewhere on the board

Notes on the sheet:
Vf=0.450
N.B. Since the 68010 is the only bus master, there is not a need to pull-up the CPU address lines to Vcc.

Parts:
C801, C802, C803, C804: 100µF; CP_Radial_D6.3mm_P2.50mm; Part Wurth 860040373002; Mouser 710-860040373002
D801: Power On; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D802: Power OK; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J801: ATX-24; Molex_Mini-Fit_Jr_5569-24A1_2x12_P4.20mm_Horizontal; Mouser 538-39-29-1248
R801, R803: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R802: 100R; R_Axial_Power_L25.0mm_W6.4mm_P27.94mm; Part Vishay / Dale CW005100R0JE73; Mouser 71-CW005100R0JE73
SW801: Power; SW_PUSH_6mm
U801: MAX16054; SOT-23-6; Mouser 700-MAX16054AZTT

Connections:
+5V: C801.1, C802.1, C803.1, C804.1, J801.4 (+5V), J801.6 (+5V), J801.21 (+5V), J801.22 (+5V), J801.23 (+5V), R801.2; also elsewhere on the board
+5Vsb: J801.9 (+5VSB), U801.6 (Vcc); also elsewhere on the board
+12V: J801.10 (+12V), J801.11 (+12V), R802.2; also elsewhere on the board
-12V: J801.14 (-12V); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, D801.1 (K), D802.1 (K), J801.3 (GND), J801.5 (GND), J801.7 (GND), J801.15 (GND), J801.17 (GND), J801.18 (GND), J801.19 (GND), J801.24 (GND), R802.1, SW801.1, U801.2 (GND), U801.3 (CLEAR); also elsewhere on the board
unnamed: D801.2 (A), R801.1
unnamed: D802.2 (A), R803.1
unnamed: J801.16 (PS_ON#), U801.4 (~OUT)
unnamed: SW801.2, U801.1 (IN)
PWR_OK: J801.8 (PWR_OK), R803.2; also elsewhere on the board

Notes on the sheet:
Dummy load for +12V rail.
General bulk capacitance.

Parts:
C501, C502, C503, C504, C505, C506, C507, C508, C509, C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C523, C524, C525, C526: 100µF; CP_Radial_D6.3mm_P2.50mm; Part Wurth 860040373002; Mouser 710-860040373002
U501: ATF1504AS-PLCC44; PLCC-44_THT-Socket; Part ATF1504AS-10JU44; Mouser 556-AF1504AS10JU44
U502, U503, U504, U505, U508, U509, U510, U511: CY62158; TSOP-II-44_10.16x18.41mm_P0.8mm; Part CY62158H-45ZSXI; JLCPCB C2950517
U506, U507: SST39SF040; DIP-32_W15.24mm_Socket; Mouser 804-39SF0407CPHE

Connections:
+5V: C501.1, C502.1, C503.1, C504.1, C505.1, C506.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C513.1, C514.1, C515.1, C516.1, C517.1, C518.1, C519.1, C520.1, C521.1, C522.1, C523.1, C524.1, C525.1, C526.1, U501.3 (VCC), U501.15 (VCC), U501.23 (VCC), U501.35 (VCC), U502.11 (VDD), U502.33 (VDD), U502.40 (CE2), U503.11 (VDD), U503.33 (VDD), U503.40 (CE2), U504.11 (VDD), U504.33 (VDD), U504.40 (CE2), U505.11 (VDD), U505.33 (VDD), U505.40 (CE2), U506.32 (VCC), U507.32 (VCC), U508.11 (VDD), U508.33 (VDD), U508.40 (CE2), U509.11 (VDD), U509.33 (VDD), U509.40 (CE2), U510.11 (VDD), U510.33 (VDD), U510.40 (CE2), U511.11 (VDD), U511.33 (VDD), U511.40 (CE2); also elsewhere on the board
/On-board memory/~OBMEM_LRD: U501.25 (I/O/PD2), U503.41 (~OE), U505.41 (~OE), U507.24 (OE), U509.41 (~OE), U511.41 (~OE)
/On-board memory/~OBMEM_LWR: U501.26 (I/O), U503.17 (~WE), U505.17 (~WE), U507.31 (PGM), U509.17 (~WE), U511.17 (~WE)
/On-board memory/~OBMEM_RAM0SEL: U501.28 (I/O), U502.6 (~CE1), U503.6 (~CE1)
/On-board memory/~OBMEM_RAM1SEL: U501.29 (I/O), U504.6 (~CE1), U505.6 (~CE1)
/On-board memory/~OBMEM_RAM2SEL: U501.31 (I/O), U508.6 (~CE1), U509.6 (~CE1)
/On-board memory/~OBMEM_RAM3SEL: U501.33 (I/O), U510.6 (~CE1), U511.6 (~CE1)
/On-board memory/~OBMEM_ROMSEL: U501.27 (I/O), U506.22 (CE), U507.22 (CE)
/On-board memory/~OBMEM_URD: U501.21 (I/O), U502.41 (~OE), U504.41 (~OE), U506.24 (OE), U508.41 (~OE), U510.41 (~OE)
/On-board memory/~OBMEM_UWR: U501.24 (I/O), U502.17 (~WE), U504.17 (~WE), U506.31 (PGM), U508.17 (~WE), U510.17 (~WE)
A1: U502.5 (A0), U503.5 (A0), U504.5 (A0), U505.5 (A0), U506.12 (A0), U507.12 (A0), U508.5 (A0), U509.5 (A0), U510.5 (A0), U511.5 (A0); also elsewhere on the board
A2: U502.4 (A1), U503.4 (A1), U504.4 (A1), U505.4 (A1), U506.11 (A1), U507.11 (A1), U508.4 (A1), U509.4 (A1), U510.4 (A1), U511.4 (A1); also elsewhere on the board
A3: U502.3 (A2), U503.3 (A2), U504.3 (A2), U505.3 (A2), U506.10 (A2), U507.10 (A2), U508.3 (A2), U509.3 (A2), U510.3 (A2), U511.3 (A2); also elsewhere on the board
A4: U502.2 (A3), U503.2 (A3), U504.2 (A3), U505.2 (A3), U506.9 (A3), U507.9 (A3), U508.2 (A3), U509.2 (A3), U510.2 (A3), U511.2 (A3); also elsewhere on the board
A5: U502.1 (A4), U503.1 (A4), U504.1 (A4), U505.1 (A4), U506.8 (A4), U507.8 (A4), U508.1 (A4), U509.1 (A4), U510.1 (A4), U511.1 (A4); also elsewhere on the board
A6: U502.44 (A5), U503.44 (A5), U504.44 (A5), U505.44 (A5), U506.7 (A5), U507.7 (A5), U508.44 (A5), U509.44 (A5), U510.44 (A5), U511.44 (A5); also elsewhere on the board
A7: U502.43 (A6), U503.43 (A6), U504.43 (A6), U505.43 (A6), U506.6 (A6), U507.6 (A6), U508.43 (A6), U509.43 (A6), U510.43 (A6), U511.43 (A6); also elsewhere on the board
A8: U502.42 (A7), U503.42 (A7), U504.42 (A7), U505.42 (A7), U506.5 (A7), U507.5 (A7), U508.42 (A7), U509.42 (A7), U510.42 (A7), U511.42 (A7); also elsewhere on the board
A9: U502.39 (A8), U503.39 (A8), U504.39 (A8), U505.39 (A8), U506.27 (A8), U507.27 (A8), U508.39 (A8), U509.39 (A8), U510.39 (A8), U511.39 (A8); also elsewhere on the board
A10: U502.28 (A9), U503.28 (A9), U504.28 (A9), U505.28 (A9), U506.26 (A9), U507.26 (A9), U508.28 (A9), U509.28 (A9), U510.28 (A9), U511.28 (A9); also elsewhere on the board
A11: U502.27 (A10), U503.27 (A10), U504.27 (A10), U505.27 (A10), U506.23 (A10), U507.23 (A10), U508.27 (A10), U509.27 (A10), U510.27 (A10), U511.27 (A10); also elsewhere on the board
A12: U502.26 (A11), U503.26 (A11), U504.26 (A11), U505.26 (A11), U506.25 (A11), U507.25 (A11), U508.26 (A11), U509.26 (A11), U510.26 (A11), U511.26 (A11); also elsewhere on the board
A13: U502.25 (A12), U503.25 (A12), U504.25 (A12), U505.25 (A12), U506.4 (A12), U507.4 (A12), U508.25 (A12), U509.25 (A12), U510.25 (A12), U511.25 (A12); also elsewhere on the board
A14: U502.24 (A13), U503.24 (A13), U504.24 (A13), U505.24 (A13), U506.28 (A13), U507.28 (A13), U508.24 (A13), U509.24 (A13), U510.24 (A13), U511.24 (A13); also elsewhere on the board
A15: U502.23 (A14), U503.23 (A14), U504.23 (A14), U505.23 (A14), U506.29 (A14), U507.29 (A14), U508.23 (A14), U509.23 (A14), U510.23 (A14), U511.23 (A14); also elsewhere on the board
A16: U502.22 (A15), U503.22 (A15), U504.22 (A15), U505.22 (A15), U506.3 (A15), U507.3 (A15), U508.22 (A15), U509.22 (A15), U510.22 (A15), U511.22 (A15); also elsewhere on the board
A17: U502.21 (A16), U503.21 (A16), U504.21 (A16), U505.21 (A16), U506.2 (A16), U507.2 (A16), U508.21 (A16), U509.21 (A16), U510.21 (A16), U511.21 (A16); also elsewhere on the board
A18: U502.20 (A17), U503.20 (A17), U504.20 (A17), U505.20 (A17), U506.30 (A17), U507.30 (A17), U508.20 (A17), U509.20 (A17), U510.20 (A17), U511.20 (A17); also elsewhere on the board
A19: U502.19 (A18), U503.19 (A18), U504.19 (A18), U505.19 (A18), U506.1 (A18), U507.1 (A18), U508.19 (A18), U509.19 (A18), U510.19 (A18), U511.19 (A18); also elsewhere on the board
A20: U502.18 (A19), U503.18 (A19), U504.18 (A19), U505.18 (A19), U508.18 (A19), U509.18 (A19), U510.18 (A19), U511.18 (A19); also elsewhere on the board
A21: U501.12 (I/O); also elsewhere on the board
A22: U501.14 (I/O); also elsewhere on the board
A23: U501.16 (I/O); also elsewhere on the board
A24: U501.17 (I/O); also elsewhere on the board
A25: U501.18 (I/O); also elsewhere on the board
A26: U501.19 (I/O); also elsewhere on the board
A27: U501.20 (I/O); also elsewhere on the board
D0: U503.9 (IO0), U505.9 (IO0), U507.13 (D0), U509.9 (IO0), U511.9 (IO0); also elsewhere on the board
D1: U503.10 (IO1), U505.10 (IO1), U507.14 (D1), U509.10 (IO1), U511.10 (IO1); also elsewhere on the board
D2: U503.13 (IO2), U505.13 (IO2), U507.15 (D2), U509.13 (IO2), U511.13 (IO2); also elsewhere on the board
D3: U503.14 (IO3), U505.14 (IO3), U507.17 (D3), U509.14 (IO3), U511.14 (IO3); also elsewhere on the board
D4: U503.31 (IO4), U505.31 (IO4), U507.18 (D4), U509.31 (IO4), U511.31 (IO4); also elsewhere on the board
D5: U503.32 (IO5), U505.32 (IO5), U507.19 (D5), U509.32 (IO5), U511.32 (IO5); also elsewhere on the board
D6: U503.35 (IO6), U505.35 (IO6), U507.20 (D6), U509.35 (IO6), U511.35 (IO6); also elsewhere on the board
D7: U503.36 (IO7), U505.36 (IO7), U507.21 (D7), U509.36 (IO7), U511.36 (IO7); also elsewhere on the board
D8: U502.9 (IO0), U504.9 (IO0), U506.13 (D0), U508.9 (IO0), U510.9 (IO0); also elsewhere on the board
D9: U502.10 (IO1), U504.10 (IO1), U506.14 (D1), U508.10 (IO1), U510.10 (IO1); also elsewhere on the board
D10: U502.13 (IO2), U504.13 (IO2), U506.15 (D2), U508.13 (IO2), U510.13 (IO2); also elsewhere on the board
D11: U502.14 (IO3), U504.14 (IO3), U506.17 (D3), U508.14 (IO3), U510.14 (IO3); also elsewhere on the board
D12: U502.31 (IO4), U504.31 (IO4), U506.18 (D4), U508.31 (IO4), U510.31 (IO4); also elsewhere on the board
D13: U502.32 (IO5), U504.32 (IO5), U506.19 (D5), U508.32 (IO5), U510.32 (IO5); also elsewhere on the board
D14: U502.35 (IO6), U504.35 (IO6), U506.20 (D6), U508.35 (IO6), U510.35 (IO6); also elsewhere on the board
D15: U502.36 (IO7), U504.36 (IO7), U506.21 (D7), U508.36 (IO7), U510.36 (IO7); also elsewhere on the board
FC0: U501.8 (I/O); also elsewhere on the board
FC1: U501.9 (I/O); also elsewhere on the board
FC2: U501.11 (I/O/PD1); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, U501.10 (GND), U501.22 (GND), U501.30 (GND), U501.42 (GND), U502.12 (GND), U502.34 (GND), U503.12 (GND), U503.34 (GND), U504.12 (GND), U504.34 (GND), U505.12 (GND), U505.34 (GND), U506.16 (GND), U507.16 (GND), U508.12 (GND), U508.34 (GND), U509.12 (GND), U509.34 (GND), U510.12 (GND), U510.34 (GND), U511.12 (GND), U511.34 (GND); also elsewhere on the board
MEMCTL_TDI: U501.7 (I/O/TDI); also elsewhere on the board
MMU_EN: U501.6 (I/O); also elsewhere on the board
OBMEM_DTACK: U501.40 (I/O); also elsewhere on the board
R/~W: U501.5 (I/O); also elsewhere on the board
TCK: U501.32 (I/O/TCK); also elsewhere on the board
TDO: U501.38 (I/O/TDO); also elsewhere on the board
TMS: U501.13 (I/O/TMS); also elsewhere on the board
~AS: U501.1 (I/GCLR); also elsewhere on the board
~EXPRAMSEL: U501.34 (I/O); also elsewhere on the board
~LDS: U501.4 (I/O); also elsewhere on the board
~UDS: U501.2 (I/OE2/GCLK2); also elsewhere on the board

Notes on the sheet:
0-2MB
6-8MB
4-6MB
2-4MB
Lower byte
Upper byte
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

Notices in the files:
nqvme_template/design-files/nqvme_template.kicad_pcb:
(c) 2026 Jason R. Thorpe.  All rights reserved.
