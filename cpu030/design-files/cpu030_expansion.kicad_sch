File: cpu030/design-files/cpu030_expansion.kicad_sch (KiCad schematic)
At the start: 19 parts, among them J801 DIN41612_03x32_ABC, U801 74ACT245, U802 74ACT245, U803 74ACT245, U804 74ACT245, U805 74ACT245, U806 74ACT245, U807 74ACT245, U808 74ACT245, U809 74ACT245

Commit message: Checkpoint: layout mostly the way I want it now.
Parts:
- J801: footprint Connector_DIN:DIN41612_R_3x32_Female_Horizontal_THT -> Connector_DIN:DIN41612_C_3x32_Female_Vertical_THT
- U801, U802, U803, U804, U805, U806, U807, U808, U809: footprint Package_DIP:DIP-20_W7.62mm_Socket -> Package_SO:SOIC-20W_7.5x12.8mm_P1.27mm; Part (none) -> 74ACT245SCX
Connections:
- net ~{DRAM1SEL} is gone; now on net D20: U809.14 (B4)
- net ~{DRAM2SEL} is gone; now on net D19: U809.15 (B3)
- net ~{DRAM3SEL} is gone; now on net D18: U809.16 (B2)
- net A0: now also U806.18 (B0); no longer U801.11 (B7)
- net A1: now also U806.17 (B1); no longer U801.12 (B6)
- net A10: now also U807.16 (B2); no longer U802.13 (B5)
- net A11: now also U807.15 (B3); no longer U802.14 (B4)
- net A12: now also U807.14 (B4); no longer U802.15 (B3)
- net A13: now also U807.13 (B5); no longer U802.16 (B2)
- net A14: now also U807.12 (B6); no longer U802.17 (B1)
- net A15: now also U807.11 (B7); no longer U802.18 (B0)
- net A16: now also U808.18 (B0); no longer U803.11 (B7)
- net A17: now also U808.17 (B1); no longer U803.12 (B6)
- net A18: now also U808.16 (B2); no longer U803.13 (B5)
- net A19: now also U808.15 (B3); no longer U803.14 (B4)
- net A2: now also U806.16 (B2); no longer U801.13 (B5)
- net A20: now also U808.14 (B4); no longer U803.15 (B3)
- net A21: now also U808.13 (B5); no longer U803.16 (B2)
- net A22: now also U808.12 (B6); no longer U803.17 (B1)
- net A23: now also U808.11 (B7); no longer U803.18 (B0)
- net A3: now also U806.15 (B3); no longer U801.14 (B4)
- net A4: now also U806.14 (B4); no longer U801.15 (B3)
- net A5: now also U806.13 (B5); no longer U801.16 (B2)
- net A6: now also U806.12 (B6); no longer U801.17 (B1)
- net A7: now also U806.11 (B7); no longer U801.18 (B0)
- net A8: now also U807.18 (B0); no longer U802.11 (B7)
- net A9: now also U807.17 (B1); no longer U802.12 (B6)
- net D0: now also U801.18 (B0); no longer U805.11 (B7)
- net D1: now also U801.17 (B1); no longer U805.12 (B6)
- net D10: now also U802.16 (B2); no longer U806.13 (B5)
- net D11: now also U802.15 (B3); no longer U806.14 (B4)
- net D12: now also U802.14 (B4); no longer U806.15 (B3)
- net D13: now also U802.13 (B5); no longer U806.16 (B2)
- net D14: now also U802.12 (B6); no longer U806.17 (B1)
- net D15: now also U802.11 (B7); no longer U806.18 (B0)
- net D16: now also U809.18 (B0); no longer U807.11 (B7)
- net D17: now also U809.17 (B1); no longer U807.12 (B6)
- net D18: no longer U807.13 (B5)
- net D19: no longer U807.14 (B4)
- net D2: now also U801.16 (B2); no longer U805.13 (B5)
- net D20: no longer U807.15 (B3)
- net D21: now also U809.13 (B5); no longer U807.16 (B2)
- net D22: now also U809.12 (B6); no longer U807.17 (B1)
- net D23: now also U809.11 (B7); no longer U807.18 (B0)
- net D24: now also U803.18 (B0); no longer U808.11 (B7)
- net D25: now also U803.17 (B1); no longer U808.12 (B6)
- net D26: now also U803.16 (B2); no longer U808.13 (B5)
- net D27: now also U803.15 (B3); no longer U808.14 (B4)
- net D28: now also U803.14 (B4); no longer U808.15 (B3)
- net D29: now also U803.13 (B5); no longer U808.16 (B2)
- net D3: now also U801.15 (B3); no longer U805.14 (B4)
- net D30: now also U803.12 (B6); no longer U808.17 (B1)
- net D31: now also U803.11 (B7); no longer U808.18 (B0)
- net D4: now also U801.14 (B4); no longer U805.15 (B3)
- net D5: now also U801.13 (B5); no longer U805.16 (B2)
- net D6: now also U801.12 (B6); no longer U805.17 (B1)
- net D7: now also U801.11 (B7); no longer U805.18 (B0)
- net D8: now also U802.18 (B0); no longer U806.11 (B7)
- net D9: now also U802.17 (B1); no longer U806.12 (B6)
- net EXP_A0: now also U806.2 (A0); no longer U801.9 (A7)
- net EXP_A1: now also U806.3 (A1); no longer U801.8 (A6)
- net EXP_A10: now also U807.4 (A2); no longer U802.7 (A5)
- net EXP_A11: now also U807.5 (A3); no longer U802.6 (A4)
- net EXP_A12: now also U807.6 (A4); no longer U802.5 (A3)
- net EXP_A13: now also U807.7 (A5); no longer U802.4 (A2)
- net EXP_A14: now also U807.8 (A6); no longer U802.3 (A1)
- net EXP_A15: now also U807.9 (A7); no longer U802.2 (A0)
- net EXP_A16: now also J801.a20 (Pin_a20), U808.2 (A0); no longer U803.9 (A7)
- net EXP_A17: now also J801.c20 (Pin_c20), U808.3 (A1); no longer U803.8 (A6)
- net EXP_A18: now also J801.a21 (Pin_a21), U808.4 (A2); no longer U803.7 (A5)
- net EXP_A19: now also J801.c21 (Pin_c21), U808.5 (A3); no longer U803.6 (A4)
- net EXP_A2: now also U806.4 (A2); no longer U801.7 (A5)
- net EXP_A20: now also J801.a22 (Pin_a22), U808.6 (A4); no longer J801.a20 (Pin_a20), U803.5 (A3)
- net EXP_A21: now also J801.c22 (Pin_c22), U808.7 (A5); no longer J801.a21 (Pin_a21), U803.4 (A2)
- net EXP_A22: now also J801.a23 (Pin_a23), U808.8 (A6); no longer J801.a22 (Pin_a22), U803.3 (A1)
- net EXP_A23: now also J801.c23 (Pin_c23), U808.9 (A7); no longer J801.a23 (Pin_a23), U803.2 (A0)
- net EXP_A3: now also U806.5 (A3); no longer U801.6 (A4)
- net EXP_A4: now also U806.6 (A4); no longer U801.5 (A3)
- net EXP_A5: now also U806.7 (A5); no longer U801.4 (A2)
- net EXP_A6: now also U806.8 (A6); no longer U801.3 (A1)
- net EXP_A7: now also U806.9 (A7); no longer U801.2 (A0)
- net EXP_A8: now also U807.2 (A0); no longer U802.9 (A7)
- net EXP_A9: now also U807.3 (A1); no longer U802.8 (A6)
- net EXP_CPU_CLK: now also U805.9 (A7)
- net EXP_D0: now also U801.2 (A0); no longer U805.9 (A7)
- net EXP_D1: now also U801.3 (A1); no longer U805.8 (A6)
- net EXP_D10: now also U802.4 (A2); no longer U806.7 (A5)
- net EXP_D11: now also U802.5 (A3); no longer U806.6 (A4)
- net EXP_D12: now also U802.6 (A4); no longer U806.5 (A3)
- net EXP_D13: now also U802.7 (A5); no longer U806.4 (A2)
- net EXP_D14: now also U802.8 (A6); no longer U806.3 (A1)
- net EXP_D15: now also U802.9 (A7); no longer U806.2 (A0)
- net EXP_D16: now also U809.2 (A0); no longer U807.9 (A7)
- net EXP_D17: now also U809.3 (A1); no longer U807.8 (A6)
- net EXP_D18: now also U809.4 (A2); no longer U807.7 (A5)
- net EXP_D19: now also U809.5 (A3); no longer U807.6 (A4)
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Other:
- moved on the sheet: U805, U807

Commit message: Remove unused bus transceiver.
Parts:
- removed C804: 100nF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed U804: 74ACT245, Package_SO:SOIC-20W_7.5x12.8mm_P1.27mm, symbol 74xx:74HC245
Connections:
- net EXP_nIACKSEL: now also U805.5 (A3); no longer U805.6 (A4)
- net EXP_nMMIOSEL: now also U805.6 (A4); no longer U805.5 (A3)
- net GND: no longer U803.1 (A->B), U803.19 (CE)
- net EXP_nRESET renamed ~{RESET}
Other:
- moved on the sheet: C805, C806, C807, C808, C809, U803, U809

Commit message: Checkpoint: I think the expansion interface is basically done?
Parts:
- renumbered C809 to C801, C801 to C802, C802 to C803, C803 to C804, U809 to U801, U801 to U802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
Connections:
- net ~{IACKSEL} is gone; now on net ~{MMIOSEL}: U805.14 (B4)
- net GND: now also J801.a26 (Pin_a26), U805.1 (A->B), U805.15 (B3), U805.19 (CE), U806.1 (A->B), U806.19 (CE), U807.1 (A->B), U807.19 (CE), U808.1 (A->B), U808.19 (CE); no longer U801.1 (A->B), U801.19 (CE), U802.1 (A->B), U802.19 (CE), U803.1 (A->B), U803.19 (CE)
- net RnW: now also U801.1 (A->B), U802.1 (A->B), U803.1 (A->B), U804.1 (A->B); no longer U805.1 (A->B), U806.1 (A->B), U807.1 (A->B), U808.1 (A->B)
- net ~{MMIOSEL}: now also U801.19 (CE), U802.19 (CE), U803.19 (CE), U804.19 (CE); no longer U805.15 (B3), U805.19 (CE), U806.19 (CE), U807.19 (CE), U808.19 (CE)
- net EXP_nIACKSEL: no longer names the net of U805.5 (A3)
- net EXP_nIACKSEL: no longer J801.a26 (Pin_a26)
- net EXP_nMMIOSEL renamed EXP_nEXPSEL
- no-connect marks 0 -> 1
Other:
- moved on the sheet: C801, C802, C803, C804, C805, C806, C807, C808
