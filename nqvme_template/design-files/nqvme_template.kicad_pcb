# Repository thorpej/pg68k (continued)

## KiCad design cpu030/design-files/cpu030.kicad_pcb (continued)

Parts:
C801, C802, C803, C804, C805, C806, C807, C808, C812, C813, C814: 100nF; C_0805_2012Metric
C809, C810, C811: 470µF; CP_Radial_D10.0mm_P5.00mm; Part ESL477M025AH9AA
J801: DIN41612_03x32_ABC; DIN41612_C_3x32_Female_Vertical_THT
R801, R802, R803, R804: 3K3; R_0805_2012Metric
RN801, RN802, RN803, RN804: 3K3; R_Array_SIP9
U801, U802, U803, U804, U805, U806, U807, U808, U809, U810: 74ACT245; SOIC-20W_7.5x12.8mm_P1.27mm; Part 74ACT245SCX
U811: GAL22V10; DIP-24_W7.62mm_Socket

Connections:
+5V: C801.1, C802.1, C803.1, C804.1, C805.1, C806.1, C807.1, C808.1, C809.1, C812.1, C813.1, C814.1, J801.b1, J801.b2, J801.b3, J801.b4, R802.2, R804.2, RN801.1 (common), RN802.1 (common), RN803.1 (common), RN804.1 (common), U801.20 (VCC), U802.20 (VCC), U803.20 (VCC), U804.20 (VCC), U805.20 (VCC), U806.20 (VCC), U807.20 (VCC), U808.20 (VCC), U809.20 (VCC), U810.20 (VCC), U811.24 (VCC); also elsewhere on the board
+12V: C810.1, J801.b32; also elsewhere on the board
-12V: C811.2, J801.c32; also elsewhere on the board
/Expansion interface/EXP_A0: J801.c1, U803.2 (A0)
/Expansion interface/EXP_A1: J801.c2, U803.3 (A1)
/Expansion interface/EXP_A2: J801.c3, U803.4 (A2)
/Expansion interface/EXP_A3: J801.c4, U803.5 (A3)
/Expansion interface/EXP_A4: J801.c5, U803.6 (A4)
/Expansion interface/EXP_A5: J801.c6, U803.7 (A5)
/Expansion interface/EXP_A6: J801.c7, U803.8 (A6)
/Expansion interface/EXP_A7: J801.c8, U803.9 (A7)
/Expansion interface/EXP_A8: J801.c9, U805.2 (A0)
/Expansion interface/EXP_A9: J801.c10, U805.3 (A1)
/Expansion interface/EXP_A10: J801.c11, U805.4 (A2)
/Expansion interface/EXP_A11: J801.c12, U805.5 (A3)
/Expansion interface/EXP_A12: J801.c13, U805.6 (A4)
/Expansion interface/EXP_A13: J801.c14, U805.7 (A5)
/Expansion interface/EXP_A14: J801.c15, U805.8 (A6)
/Expansion interface/EXP_A15: J801.c16, U805.9 (A7)
/Expansion interface/EXP_A16: J801.c17, U806.2 (A0)
/Expansion interface/EXP_A17: J801.c18, U806.3 (A1)
/Expansion interface/EXP_A18: J801.c19, U806.4 (A2)
/Expansion interface/EXP_A19: J801.c20, U806.5 (A3)
/Expansion interface/EXP_A20: J801.c21, U806.6 (A4)
/Expansion interface/EXP_A21: J801.c22, U806.7 (A5)
/Expansion interface/EXP_A22: J801.c23, U806.8 (A6)
/Expansion interface/EXP_A23: J801.c24, U806.9 (A7)
/Expansion interface/EXP_A24: J801.c25, U807.2 (A0)
/Expansion interface/EXP_A25: J801.c26, U807.3 (A1)
/Expansion interface/EXP_A26: J801.c27, U807.4 (A2)
/Expansion interface/EXP_A27: J801.c28, U807.5 (A3)
/Expansion interface/EXP_A28: J801.c29, U807.6 (A4)
/Expansion interface/EXP_A29: J801.c30, U807.7 (A5)
/Expansion interface/EXP_A30: J801.c31, U807.8 (A6)
/Expansion interface/EXP_A31: J801.b31, U807.9 (A7)
/Expansion interface/EXP_ADIR: U803.1 (A->B), U804.1 (A->B), U805.1 (A->B), U806.1 (A->B), U807.1 (A->B), U811.14 (IO1)
/Expansion interface/EXP_CPU_CLK: J801.b14, U810.4 (A2)
/Expansion interface/EXP_D0: J801.a25, RN804.2 (R1), U809.2 (A0)
/Expansion interface/EXP_D1: J801.a26, RN804.3 (R2), U809.3 (A1)
/Expansion interface/EXP_D2: J801.a27, RN804.4 (R3), U809.4 (A2)
/Expansion interface/EXP_D3: J801.a28, RN804.5 (R4), U809.5 (A3)
/Expansion interface/EXP_D4: J801.a29, RN804.6 (R5), U809.6 (A4)
/Expansion interface/EXP_D5: J801.a30, RN804.7 (R6), U809.7 (A5)
/Expansion interface/EXP_D6: J801.a31, RN804.8 (R7), U809.8 (A6)
/Expansion interface/EXP_D7: J801.a32, RN804.9 (R8), U809.9 (A7)
/Expansion interface/EXP_D8: J801.a17, RN803.2 (R1), U808.2 (A0)
/Expansion interface/EXP_D9: J801.a18, RN803.3 (R2), U808.3 (A1)
/Expansion interface/EXP_D10: J801.a19, RN803.4 (R3), U808.4 (A2)
/Expansion interface/EXP_D11: J801.a20, RN803.5 (R4), U808.5 (A3)
/Expansion interface/EXP_D12: J801.a21, RN803.6 (R5), U808.6 (A4)
/Expansion interface/EXP_D13: J801.a22, RN803.7 (R6), U808.7 (A5)
/Expansion interface/EXP_D14: J801.a23, RN803.8 (R7), U808.8 (A6)
/Expansion interface/EXP_D15: J801.a24, RN803.9 (R8), U808.9 (A7)
/Expansion interface/EXP_D16: J801.a9, RN802.2 (R1), U802.2 (A0)
/Expansion interface/EXP_D17: J801.a10, RN802.3 (R2), U802.3 (A1)
/Expansion interface/EXP_D18: J801.a11, RN802.4 (R3), U802.4 (A2)
/Expansion interface/EXP_D19: J801.a12, RN802.5 (R4), U802.5 (A3)
/Expansion interface/EXP_D20: J801.a13, RN802.6 (R5), U802.6 (A4)
/Expansion interface/EXP_D21: J801.a14, RN802.7 (R6), U802.7 (A5)
/Expansion interface/EXP_D22: J801.a15, RN802.8 (R7), U802.8 (A6)
/Expansion interface/EXP_D23: J801.a16, RN802.9 (R8), U802.9 (A7)
/Expansion interface/EXP_D24: J801.a1, RN801.2 (R1), U801.2 (A0)
/Expansion interface/EXP_D25: J801.a2, RN801.3 (R2), U801.3 (A1)
/Expansion interface/EXP_D26: J801.a3, RN801.4 (R3), U801.4 (A2)
/Expansion interface/EXP_D27: J801.a4, RN801.5 (R4), U801.5 (A3)
/Expansion interface/EXP_D28: J801.a5, RN801.6 (R5), U801.6 (A4)
/Expansion interface/EXP_D29: J801.a6, RN801.7 (R6), U801.7 (A5)
/Expansion interface/EXP_D30: J801.a7, RN801.8 (R7), U801.8 (A6)
/Expansion interface/EXP_D31: J801.a8, RN801.9 (R8), U801.9 (A7)
/Expansion interface/EXP_DDIR: U801.1 (A->B), U802.1 (A->B), U808.1 (A->B), U809.1 (A->B), U811.15 (IO2)
/Expansion interface/EXP_RnW: J801.b11, U804.6 (A4)
/Expansion interface/EXP_SIZ0: J801.b9, U804.4 (A2)
/Expansion interface/EXP_SIZ1: J801.b10, U804.5 (A3)
/Expansion interface/EXP_nAS: J801.b7, U804.2 (A0)
/Expansion interface/EXP_nDS: J801.b8, U804.3 (A1)
/Expansion interface/EXP_nEXPSEL: J801.b12, U810.2 (A0)
/Expansion interface/EXP_nRESET: J801.b13, U810.3 (A1)
/Expansion interface/~EXP_DEN: U801.19 (CE), U802.19 (CE), U808.19 (CE), U809.19 (CE), U811.16 (IO3)
A0: U803.18 (B0); also elsewhere on the board
A1: U803.17 (B1); also elsewhere on the board
A2: U803.16 (B2); also elsewhere on the board
A3: U803.15 (B3); also elsewhere on the board
A4: U803.14 (B4); also elsewhere on the board
A5: U803.13 (B5); also elsewhere on the board
A6: U803.12 (B6); also elsewhere on the board
A7: U803.11 (B7); also elsewhere on the board
A8: U805.18 (B0); also elsewhere on the board
A9: U805.17 (B1); also elsewhere on the board
A10: U805.16 (B2); also elsewhere on the board
A11: U805.15 (B3); also elsewhere on the board
A12: U805.14 (B4); also elsewhere on the board
A13: U805.13 (B5); also elsewhere on the board
A14: U805.12 (B6); also elsewhere on the board
A15: U805.11 (B7); also elsewhere on the board
A16: U806.18 (B0); also elsewhere on the board
A17: U806.17 (B1); also elsewhere on the board
A18: U806.16 (B2); also elsewhere on the board
A19: U806.15 (B3); also elsewhere on the board
A20: U806.14 (B4); also elsewhere on the board
A21: U806.13 (B5); also elsewhere on the board
A22: U806.12 (B6); also elsewhere on the board
A23: U806.11 (B7); also elsewhere on the board
A24: U807.18 (B0); also elsewhere on the board
A25: U807.17 (B1); also elsewhere on the board
A26: U807.16 (B2); also elsewhere on the board
A27: U807.15 (B3); also elsewhere on the board
A28: U807.14 (B4); also elsewhere on the board
A29: U807.13 (B5); also elsewhere on the board
A30: U807.12 (B6); also elsewhere on the board
A31: U807.11 (B7); also elsewhere on the board
CPU_CLK: U810.16 (B2); also elsewhere on the board
D0: U809.18 (B0); also elsewhere on the board
D1: U809.17 (B1); also elsewhere on the board
D2: U809.16 (B2); also elsewhere on the board
D3: U809.15 (B3); also elsewhere on the board
D4: U809.14 (B4); also elsewhere on the board
D5: U809.13 (B5); also elsewhere on the board
D6: U809.12 (B6); also elsewhere on the board
D7: U809.11 (B7); also elsewhere on the board
D8: U808.18 (B0); also elsewhere on the board
D9: U808.17 (B1); also elsewhere on the board
D10: U808.16 (B2); also elsewhere on the board
D11: U808.15 (B3); also elsewhere on the board
D12: U808.14 (B4); also elsewhere on the board
D13: U808.13 (B5); also elsewhere on the board
D14: U808.12 (B6); also elsewhere on the board
D15: U808.11 (B7); also elsewhere on the board
D16: U802.18 (B0); also elsewhere on the board
D17: U802.17 (B1); also elsewhere on the board
D18: U802.16 (B2); also elsewhere on the board
D19: U802.15 (B3); also elsewhere on the board
D20: U802.14 (B4); also elsewhere on the board
D21: U802.13 (B5); also elsewhere on the board
D22: U802.12 (B6); also elsewhere on the board
D23: U802.11 (B7); also elsewhere on the board
D24: U801.18 (B0); also elsewhere on the board
D25: U801.17 (B1); also elsewhere on the board
D26: U801.16 (B2); also elsewhere on the board
D27: U801.15 (B3); also elsewhere on the board
D28: U801.14 (B4); also elsewhere on the board
D29: U801.13 (B5); also elsewhere on the board
D30: U801.12 (B6); also elsewhere on the board
D31: U801.11 (B7); also elsewhere on the board
FC0: U804.13 (B5); also elsewhere on the board
FC1: U804.12 (B6); also elsewhere on the board
FC2: U804.11 (B7); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, C807.2, C808.2, C809.2, C810.2, C811.1, C812.2, C813.2, C814.2, J801.b27, J801.b28, J801.b29, J801.b30, R801.2, R803.2, U801.10 (GND), U802.10 (GND), U803.10 (GND), U803.19 (CE), U804.10 (GND), U804.19 (CE), U805.10 (GND), U805.19 (CE), U806.10 (GND), U806.19 (CE), U807.10 (GND), U807.19 (CE), U808.10 (GND), U809.10 (GND), U810.1 (A->B), U810.10 (GND), U810.19 (CE), U811.12 (GND); also elsewhere on the board
I2C_SCL: J801.b6; also elsewhere on the board
I2C_SDA: J801.b5; also elsewhere on the board
unnamed: R804.1, U804.7 (A5)
unnamed: R803.1, U804.8 (A6)
unnamed: R802.1, U804.9 (A7)
unnamed: R801.1, U810.5 (A3), U810.6 (A4), U810.7 (A5), U810.8 (A6), U810.9 (A7), U810.11 (B7), U810.12 (B6), U810.13 (B5), U810.14 (B4), U810.15 (B3)
RnW: U804.14 (B4), U811.2 (I2); also elsewhere on the board
SIZ0: U804.16 (B2); also elsewhere on the board
SIZ1: U804.15 (B3); also elsewhere on the board
~AS: U804.18 (B0), U811.1 (I1/CLK); also elsewhere on the board
~CPU_BERR: J801.b18; also elsewhere on the board
~CPU_BGACK: J801.b26, U811.4 (I4); also elsewhere on the board
~CPU_BG: J801.b25; also elsewhere on the board
~CPU_BR: J801.b24; also elsewhere on the board
~CPU_CIIN: J801.b17; also elsewhere on the board
~CPU_DBEN: U811.3 (I3); also elsewhere on the board
~CPU_DSACK0: J801.b15; also elsewhere on the board
~CPU_DSACK1: J801.b16; also elsewhere on the board
~DS: U804.17 (B1); also elsewhere on the board
~EXPSEL: U810.18 (B0), U811.5 (I5); also elsewhere on the board
~INT2: J801.b19; also elsewhere on the board
~INT3: J801.b20; also elsewhere on the board
~INT4: J801.b21; also elsewhere on the board
~INT5: J801.b22; also elsewhere on the board
~INT6: J801.b23; also elsewhere on the board
~RESET: U810.17 (B1); also elsewhere on the board

Notes on the sheet:
Codes "Supervisor Data"
EXPGLUE

Parts:
BT601: CR1220; BatteryHolder_Keystone_500; Part Keystone 500
C601, C602: 100nF; C_0805_2012Metric
R601, R602, R603: 4K7; R_0805_2012Metric
U601: PCF8584; DIP-20_W7.62mm_Socket
U602: DS3231MZ; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C601.1, C602.1, R601.1, R602.1, R603.1, U601.20 (VDD), U602.2 (VCC); also elsewhere on the board
A0: U601.6 (A0); also elsewhere on the board
CLK_6_25: U601.1 (CLK); also elsewhere on the board
D24: U601.7 (D0); also elsewhere on the board
D25: U601.8 (D1); also elsewhere on the board
D26: U601.9 (D2); also elsewhere on the board
D27: U601.11 (D3); also elsewhere on the board
D28: U601.12 (D4); also elsewhere on the board
D29: U601.13 (D5); also elsewhere on the board
D30: U601.14 (D6); also elsewhere on the board
D31: U601.15 (D7); also elsewhere on the board
GND: BT601.2 (-), C601.2, C602.2, U601.10 (VSS), U602.5 (GND); also elsewhere on the board
I2C_SCL: R603.2, U601.3 (SCL), U602.8 (SCL); also elsewhere on the board
I2C_SDA: R602.2, U601.2 (SDA), U602.7 (SDA); also elsewhere on the board
unnamed: BT601.1 (+), U602.6 (VBAT)
unnamed: R601.2, U601.4 (~IACK)
RnW: U601.18 (~WR); also elsewhere on the board
~CPU_DSACK0: U601.16 (~RD); also elsewhere on the board
~I2CSEL: U601.17 (~CS); also elsewhere on the board
~INT5: U601.5 (~INT); also elsewhere on the board
~RESET: U601.19 (~RST); also elsewhere on the board

Schematic: cpu030_psu.kicad_sch

Parts:
C901: 470µF; CP_Radial_D10.0mm_P5.00mm; Part ESL477M025AH9AA
C902, C903: 100nF; C_0805_2012Metric
D901: Power; LED_D3.0mm
J901: ATX-24; Molex_Mini-Fit_Jr_5569-24A1_2x12_P4.20mm_Horizontal; Part 39-29-1248
R901: 470; R_0805_2012Metric
SW901: Power; SW_PUSH_6mm
U901: ATtiny85-20P; DIP-8_W7.62mm_Socket
U902: 74HCT74; SOIC-14_3.9x8.7mm_P1.27mm; Part MM74HCT74MX

Connections:
+3V3: J901.1 (+3.3V), J901.2 (+3.3V), J901.12 (+3.3V), J901.13 (+3.3V)
+5V: C901.1, J901.4 (+5V), J901.6 (+5V), J901.21 (+5V), J901.22 (+5V), J901.23 (+5V); also elsewhere on the board
+12V: J901.10 (+12V), J901.11 (+12V); also elsewhere on the board
-12V: J901.14 (-12V); also elsewhere on the board
/Power Supply/PSU_HOST_REQ: U901.6 (PB1), U902.5 (Q)
/Power Supply/PSU_HOST_REQ_BIT0: U901.5 (AREF/PB0), U902.9 (Q)
/Power Supply/Vsb: C902.1, C903.1, J901.9 (+5VSB), U901.8 (VCC), U902.1 (~R), U902.10 (~S), U902.14 (VCC)
/Power Supply/~PS_ON: J901.16 (PS_ON#), U901.2 (XTAL1/PB3)
D0: U902.12 (D); also elsewhere on the board
GND: C901.2, C902.2, C903.2, D901.1 (K), J901.3 (GND), J901.5 (GND), J901.7 (GND), J901.15 (GND), J901.17 (GND), J901.18 (GND), J901.19 (GND), J901.24 (GND), SW901.2, U901.4 (GND), U902.2 (D), U902.7 (GND); also elsewhere on the board
unnamed: D901.2 (A), R901.2
PWR_LED: R901.1, U901.3 (XTAL2/PB4)
PWR_OK: J901.8 (PWR_OK); also elsewhere on the board
~PSUSEL: U902.3 (C), U902.11 (C); also elsewhere on the board
~PWR_BUT: SW901.1, U901.7 (PB2); also elsewhere on the board
~RESET: U901.1 (~RESET/PB5), U902.4 (~S), U902.13 (~R); also elsewhere on the board

Notes on the sheet:
See psu-ctrl.ino

Board: 6 copper layers, 259.9 x 154.9 mm, 233 parts (21 on the bottom side), 358 nets.

## Code that names these connections

File system_rom/cpu010_mmu.h:

/*
 * Copyright (c) 2025, 2026 Jason R. Thorpe.
 * All rights reserved.
 *
 * Redistribution and use in source and binary forms, with or without
 * modification, are permitted provided that the following conditions
 * are met:
 * 1. Redistributions of source code must retain the above copyright
 *    notice, this list of conditions and the following disclaimer.
 * 2. Redistributions in binary form must reproduce the above copyright
 *    notice, this list of conditions and the following disclaimer in the
 *    documentation and/or other materials provided with the distribution.
 *
 * THIS SOFTWARE IS PROVIDED BY THE AUTHOR ``AS IS'' AND ANY EXPRESS OR
 * IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE IMPLIED WARRANTIES
 * OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE DISCLAIMED.
 * IN NO EVENT SHALL THE AUTHOR BE LIABLE FOR ANY DIRECT, INDIRECT,
 * INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES (INCLUDING,
 * BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES;
 * LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED
 * AND ON ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY,
 * OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY
 * OUT OF THE USE OF THIS SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF
 * SUCH DAMAGE.
 */

#ifndef _CPU010_MMU_H_
#define	_CPU010_MMU_H_

/*
 * Definitions for the Phaethon 1 MMU.
 *
 * The Phaethon 1 MMU is inspired by the Sun3 MMU (which is itself similar
 * to the Sun2 MMU), but has some differences.  Here are the features of
 * the Phaethon 1's MMU:
 *
 * ==> 24 bits of virtual address (16MB, as limited by the 68010) is mapped
 *     onto 28 bits (256MB) of physical address.
 *
 * ==> 64 contexts; kernel accessess all use context 0, leaving 1-63
 *     available for user processes.  There is no restriction against
 *     using context 0 for user processes, and there is per-page kernel
 *     privilege protection in case you do.
 *
 * ==> 2-level address translation: each context is comprised of 512
 *     32KB segments, and each segment is comprised of 8 4KB pages.
 *
 * ==> A total of 262,144 32-bit Page Map entries.  Because of the 8-entry
 *     grouping, there are a total of 32,768 Page Map Entry Groups (PMEGs)
 *     shared by all contexts.  Thus, each Segment Map entry is 16 bits
 *     (16-bit PMEG index plus a VALID bit).
 *
 *     This is actually another key difference from the Sun MMU.  With
 *     the Sun MMU, PMEGs were a fairly scarce resource.  Here, there
 *     are a lot of them... in fact, enough to fully map then entirety
 *     of all 64 contexts (32,768 / 64 == 512).  This implies that we
 *     shouldn't burn too much memory on a per-PMEG basis to manage them.
 *
 * ==> Independent access to the Page Map entries.  This is a key difference
 *     from the Sun MMU, which always uses the context register + Segment
 *     Map to address Page Map entries.  The Phaethon 1's MMU has an address
 *     mux in front of the Page Map, which selects where the Page Map entry
 *     index comes from.
 *
 * ==> Protection on a per-page basis: K (kernel privilege required) and
 *     W (writable).
 *
 * ==> Page Referenced and Modified tracking.
 *
 * ==> Fast access to the kernel segment map via a dedicated address range
 *     for this purpose.
 *
 * ==> Separate reporting for privilege (user access to kernel-only page)
 *     and protection (write access to read-only page) violations, with
 *     privilege violation reporting taking priority.
 *
 * ==> Centralized bus error handling for the whole system, include a
 *     a bus cycle watchdog timer.
 *
 * ==> MMU register access via FC#4.
 *
 * ==> Separate MMU-enable signal.
 *
 * Address translation:
 *
 * +---------------+--------------------+
 * | Context [5:0] | Segment [VA 23:15] |
 * +---------------+--------------------+--> 15-bit SegMap index --+
 *                                                                 |
 * +---------------------------------------------------------------+
 * |
 * +--> SegMap contains 15-bit PMEG index --+
 *                                          |
 * +----------------------------------------+
 * |
 * +----------------------------+
 * |         PageMap index      |
 * | PMEG -> [17:3] | VA[14:12] |
 * +----------------------------+--> 18-bit PageMap index --+
 *                                                          |
 * +--------------------------------------------------------+
 * |
 * +--> PageMap entry (32-bits) (lower 16 bits are PFN) -----+
 *                                                           |
 * +---------------------------------------------------------+
 * |
 * +--> (PFN << 12) | VA[11:0] -> PROFIT!
 *
 * Format of a Page Map entry:
 *
 *  31          28   26         23         20 19 16 15                0
 * | V | W | K |  (r)  | R | M | s3 s2 s1 s0 | (r) | Page Frame Number |
 * | a   r   e     e     e   o   (software      e
 * | l   i   r     s     f   d      defined)    s
 * | i   t   n     e     e   i                  e
 * | d   e   e     r     r   f                  r
 *           l     v     e   i                  v
 *                 e     n   e                  e
 *                 d     c   d                  d
 *                       e
 *                       d
 */

#define	PGMMU_NUM_CONTEXTS 64		/* 64 total contexts */
#define	PGMMU_CONTEXT_SUPER 0		/* supervisor is always context 0 */

#define	PGMMU_NUM_SEGS	512		/* 512 segments per context */
#define	PGMMU_SEG_SIZE	(0x01000000 / PGMMU_NUM_SEGS)
#define	PGMMU_SEG_OFFSET (PGMMU_SEG_SIZE - 1)
#define	PGMMU_SEGNUM(va) ((va) / PGMMU_SEG_SIZE)

#define	PGMMU_NUM_PMEGS	32768		/* 32K total Page Map Entry Groups */
#define	PGMMU_PMES_PER_PMEG 8		/* 8 PMEs per PMEG */
#define	PGMMU_NUM_PMES	(PGMMU_NUM_PMEGS * PGMMU_PMES_PER_PMEG)

#define	PAGE_SHIFT	12		/* 4K pages */
#define	PAGE_SIZE	(1 << PAGE_SHIFT)
#define	PAGE_OFFSET	(PAGE_SIZE - 1)

#define	SME_PMEG	0x7fff		/* Page Map Entry Group for segment */
#define	SME_V		0x8000		/* Segment Map entry valid */

#define	PME_PFN		0x0000ffff	/* Page Frame Number (PA >> 12) */
#define	PME_SW0		0x00100000	/* software defined bits */
#define	PME_SW1		0x00200000
#define	PME_SW2		0x00400000
#define	PME_SW3		0x00800000
#define	PME_MOD		0x01000000	/* page was modified */
#define	PME_REF		0x02000000	/* page was referenced */
#define	PME_K		0x20000000	/* kernel-only page */
#define	PME_W		0x40000000	/* writable page */
#define	PME_V		0x80000000	/* Page Map entry valid */

/*
 * FC#4 is used by the MMU as "control space".  CPU address bits A3..A1
 * are used as a register selector, and the space is decoded like so:
 *
 *                          selector bits
 *                               vvv
 *      xxxx.xxxx xxxx.xxxx xxxx.000x   non-MMU control space (ignored)
 *      SSSS.SSSS Sxxx.xxxx xxxx.0010   SegMap entry for Context 0
 *      SSSS.SSSS Sxxx.xxxx xxxx.0100   SegMap entry (relative to Context Reg)
 *      xxxx.xxxx xxxx.xxxx xxxx.0110   Context Register (byte)
 *      xxGG.GGGG GGGG.GGGG GEEE.1000   PageMap entry (upper word)
 *      xxGG.GGGG GGGG.GGGG GEEE.1010   PageMap entry (lower word)
 *        ^^^^^^^^^^^^^^^^^^^|||
 *                 PMEG      |||
 *                           ^^^
 *                    Entry within PMEG
 *      xxxx.xxxx xxxx.xxxx xxxx.1100   Bus Error Register (byte)
 *      xxxx.xxxx xxxx.xxxx xxxx.1110   (unused; reserved)
 */
#define	MMU_CTLSEL_SEGMAP0	0x02
#define	MMU_CTLSEL_SEGMAP	0x04
#define	MMU_CTLSEL_CONTEXT	0x06
#define	MMU_CTLSEL_PAGEMAP_U	0x08
#define	MMU_CTLSEL_PAGEMAP_L	0x0a
#define	MMU_CTLSEL_PAGEMAP	MMU_CTLSEL_PAGEMAP_U
#define	MMU_CTLSEL_BUSERROR	0x0c

#define	MMUREG_SEGMAP0_ENTRY(seg) (((seg) << 15) | MMU_CTLSEL_SEGMAP0)
#define	MMUREG_SEGMAP_ENTRY(seg)  (((seg) << 15) | MMU_CTLSEL_SEGMAP)
#define	MMUREG_CONTEXT		  (MMU_CTLSEL_CONTEXT)
#define	MMUREG_PMEG_ENTRY(pmeg, e) \
		(((pmeg) << 7) | (((e) % PGMMU_PMES_PER_PMEG) << 4) \
			       | MMU_CTLSEL_PAGEMAP)
#define	MMUREG_PAGEMAP_ENTRY(e) \
		(((e) << 4) | MMU_CTLSEL_PAGEMAP)
#define	MMUREG_BUSERROR		(MMU_CTLSEL_BUSERROR)

/*
 * Bus Error Register
 *
 * The Bus Error Register contains the cause of the most recent
 * bus error.  It is reset when read; writes are ignored.
 */
#define	BERR_INVALID	0x01	/* invalid translation */
#define	BERR_PROT	0x02	/* protection error (ro page) */
#define	BERR_PRIV	0x04	/* privilege error (ko page) */
#define	BERR_TIMEOUT	0x10	/* bus cycle watchdog timed out */
#define	BERR_VME	0x20	/* VMEbus /BERR asserted */

	/* short-hand for "any MMU page fault type" */
#define	BERR_PAGEFAULT	(BERR_INVALID|BERR_PROT|BERR_PRIV)

#endif /* _CPU010_MMU_H_ */

## Commit log (part)

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2026-01-13 Tidy up the Bus Error controller a little, in preparation for folding it into the MMU.
    Also make sure the Bus Error register reflects exactly the most recent
    bus error.
2026-01-13 More cosmetic changes.
2026-01-14 Put the Bus Error Register into the MMU.
2026-01-14 Fix I/O pin assignment.
2026-01-14 Expansion bus changes: - VME bus arb signals are now total no-ops, no daisy-chain. - Ditto for VMS IACK signals. - Neuter some other VME control signals.
2026-01-15 Wire up some memory bits.
2026-01-15 Pretty much have the memory wired up.
2026-01-15 Route a bunch of I/O controller signals.
2026-01-17 More routing of I/O signals. Change the I2C pullups to 1K.
2026-01-17 Eliminate the '245 between the VME glue GAL and the AM signals.
2026-01-17 Separate I2C interrupt input, internally routed to IRQ3.
2026-01-17 Auto-vector interrupts are signalled via /VPA on the 68010.
2026-02-02 Add some additional run-time support routines needed by 68010.
2026-02-02 Also need __modsi3 on 68010.
2026-02-02 Allow fixed-size memory regions to be reported. Print a CPU description string if specified.
2026-02-02 Need __ffssi2 and __muldi3
2026-02-03 Commands to interact with the MMU.
2026-02-03 Map the ROM read-only
2026-02-04 Add an "uptime" command.
2026-02-04 Interrupt support.
2026-02-04 Initialize at the start, and quiesce interrupts at exec.
2026-02-05 Improve a help message.
2026-02-05 Add a version command, re-factor reboot().
2026-02-05 Don't hard-code the page size in malloc().
2026-02-05 Beginnings of trap handling.
2026-02-05 Add a probe command, as well, that exercises the "badaddr" path.
2026-02-06 Fix packing of ext8.
2026-02-06 Fix the ATA_AUX selector. We need have DA[2:1] high on the ATA interface in addition to asserting CS3FX-. The easiest way to do that is just to define ATA_AUX as a full 8-register range.
2026-02-07 Rename atareg.h -> wdc1003reg.h
2026-02-07 Many many bus connections.
2026-02-08 Fix some wards in the "probe" command.
2026-02-12 Just print one ATA controller address.
2026-02-12 Undef INADDR_BROADCAST before defining it.
2026-02-12 De-collide reboot() from system namespace on the host sim.
2026-02-13 hellorld!
2026-02-13 Rework how boot / reboot / halt disposition works. There are now 4 "howto" boot dispositions: default (check config setting for auto-boot), reboot-noauto (mainly used internally by the firmware for t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
    "reboot" and "halt" still execute a full reboot, but firmware boot
    messages are suppressed for a cleaner experience.
    Note that auto-boot and reboot are not yet implemented (no way to
    store default boot path or query configuration settings).
2026-02-13 Add a "devs" command to print device configuration.
2026-02-13 Support probing expansion RAM on 68010, requires use of MMU.
2026-02-13 In dev_open(), only refresh f_devpart if choosing the partition succeeds. Fixes the following incorrect error message:
    >>> ls ata(0,0,4)
    Found GUID Partition Table partition scheme
    ata(0,0,0): No such process
    ls: Not a directory
    >>>
2026-02-13 Make some messages only-if-verbose. Verbose is off by default, and it can be changed by the "verbose" command.
2026-02-13 mmu_unmap(): invalidate segments that have fully-invalid PMEGs.
2026-02-19 Device tree for Phaethon 1.
2026-02-19 Print out device tree updates in verbose mode.
2026-02-19 Use device tree on the Phaethon 1.
2026-02-20 Build bootinfo.o
2026-02-20 When setting bootinfo, derive the size from a longword-rounded address, not the address from a longword-rounded size. We do this because the assumed alignment of the first record is only word-aligned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
    Word-alignment of the first record is dumb, yes, but that's apparently
    the way Linux does it (matches the user-space ABI they historically used).
2026-02-20 Fix comment-within-comment.
2026-02-20 Fix some silly mistakes revealed by compiler warnings.
2026-02-20 Fix ambiguous parens.
2026-02-20 Fix a verbose_printf() statement.
2026-02-20 Add -Wall.
2026-02-20 -Wstrict-prototypes
2026-02-21 PROGRESS for the LOAD_BOOTINFO case.
2026-02-21 Terminate the bootinfo records correctly, and actually set the tags (oops). Also pass boot args via command line bootinfo record.
2026-02-21 Make 8-bit ATA PIO a config option.
2026-02-21 Dynamically compute the romcall vector base.
2026-02-21 Keep %a2 as the call vector.
2026-02-21 AFLAGS, not ASFLAGS
2026-02-22 Formatting tweaks.
2026-02-22 Panic if main() returns.
2026-02-24 Take "PG68K" out of the bootinfo extensions... FDT Platform instead.
2026-02-24 Start documenting the Phaethon 1.
2026-02-24 Fix vmeglue link.
2026-02-25 Sescribe the Segment Map control.
2026-02-25 The MMU only writes-back the upper 8 bits of the PME, not the upper 16.
2026-02-26 Eliminate AccessValid; use ProtOK instead.
2026-02-26 Don't continuously latch PME_copy; only do it while waiting for a bus cycle to start. By the time we see the synchronized /AS signal, the PME will have stabilized.
2026-02-27 Make /AS, /UDS, /LDS more combinatorial; only rely on nAS_s for the sequential portion of the logic.
2026-02-27 Add extra states to control the PME index latch, de-coupling it from the negation of /AS.
2026-02-27 Always gate the output strobes on nAS_s to allow for switching and propagation delay through the address output muxes.
2026-02-27 Shuffle some things around to group them more logically, and add comments noting the various sections. Get the PME bits from PME_copy.
2026-02-27 KernelAcc can be reduced to simply looking at FC[2]. No need to consider RegularSpace in that computation because KernelAcc only matters when Translate is true, and RegularSpace is already accounted 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
2026-02-28 Remove obsolete scribbings.
2026-02-28 Revert "Revert "Remove obsolete scribbings.""
    This reverts commit a06ec92ac30b727c8e785a30035efdfcdb36fe82.
2026-02-28 Add a "spotless" that removes .fit and .jed files, too.
2026-03-01 Fix qualification of n_berr_out; we want n_berr_out to go high as soon as the CPU's /AS signal goes high.
2026-03-03 Start the MMU test suite: - MMU clock generation - MMU read cycle with MMU disabled - MMU read cycle, supervisor, successful
2026-03-03 Add test case for successful supervisor translated write.
2026-03-04 Add read_super_inv, write_super_inv, and write_user_prot test cases.
2026-03-04 Provide a hook for testbench code to peek at the Bus Error Register.
2026-03-04 Fill out all 8 bits of bus_error_reg_test_out.
2026-03-04 Add mmu_read_user_ok and mmu_read_user_inv test cases.
2026-03-04 Add a comment to this effect.
2026-03-04 Add back in the mmu_write test cases.
2026-03-04 correct test descriptions.
2026-03-04 Add r-m-w OK test case.
2026-03-04 Add mmu_rmw_super_prot test case.
2026-03-04 Get dumpfile name from macro.
2026-03-04 Add mmu_read_super_inv_sme test case; this is like mmu_read_super_inv, but it has a valid PME and an invalid SME. This ensures that !SME_V results in an invalid translation error.
2026-03-05 Fix a bug uncovered in testing: When computing CTX, KernelAcc needs to be qualified with RegularSpace ever since KernelAcc itself was simplified.
2026-03-05 Add mmu_segmap test case.
2026-03-06 Add mmu_pagemap test cases.
2026-03-06 Provide a test hook for introspecing bus_timer.
2026-03-06 Add mmu_berr_reg test case.
2026-03-10 Don't use non-standard CPU / MMU values on 68010.
2026-04-21 Don't bother with a clock node for the UARTs; use clock-frequency instead.
2026-04-23 Add a DD7SEG driver and a rom call for it. Cutesy-ify the firmware banner.
2026-05-02 8 open file total
2026-05-03 Fix logo formatting.
2026-06-07 Add some passives for signal integrity, work on some additional signal routing.
2026-06-07 More signal routing progress.
2026-06-07 There is not a separate VME termination sheet.
2026-06-07 Add POWER OK LED
2026-06-08 DRC checkpoint - no more unconnected items.
2026-06-08 DRC checkpoint -- adjusted all VIAs for JLPCB's recommended minimums, tweaked placement with small grid as needed.
2026-06-08 Groundfillmaxxing.
2026-06-08 One small silk screen tweak.
2026-06-08 Change the VME dummy pull resistors from 470R to 10K.
2026-06-09 Name / rev / copyright.
2026-06-09 Rev A schematic and PCB render.
2026-06-09 Gerber / drill files for Rev A.
2026-06-09 Change all LEDs to red 0603 to address parts availability.
2026-06-09 Add bom and cpl files for JLCPCB.
2026-06-09 Regen Gerbers.
2026-06-10 Fix some BOM issues.
2026-06-12 Some unsaved changes that are inconsequential.
2026-06-12 First errata for Rev A:
    There D6 and D7 are swapped on the expansion slots due to an error in
    the schematic. Bump the board to Rev B, correct the schematic and PCB,
    and describe the rework needed for Rev A board to correct the problem.
2026-06-12 Add a schematic / PCB template for NQVME expansion boards.
2026-06-13 Lay out the 22V10.
2026-06-14 Define control space registers for board and PLD revision. Hardware reports board rev as ASCII 'A' - 'Z', emulators use numbers outside that range. Define TME and MAME emulator constants.
2026-06-14 Add experimental support for disk image files.
2026-06-14 Make a run-time decision about 8-bit PIO, based on board revision (singling out TME).
2026-06-15 Add board and pld revision registers.
2026-06-15 Fix typo in comment.
2026-06-15 Oops, wasn't considering /AS in the internal "enable decode" logic.
2026-06-15 Add some memctl tests.
2026-06-15 Add MEMCTL DTACK tests.
2026-06-15 Fix some comments.
2026-06-16 Fix mis-ordered address bit-slice.
2026-06-16 Fix INT_EN handling, and rename IPL -> nIPL to reflect that it's inverted going out to the CPU.
2026-06-16 Add IOCTL obio decode test.
2026-06-16 Set DTACK and /AVEC according to the state machine.
2026-06-17 Add IORST test case.
2026-06-17 Further simplify the state machine logic.
2026-06-17 Add BPACK test case.
2026-06-17 Introduce a FAST_DTACK node, which combinatorialy asserts DTACK before the state machine gets around to it; this avoids adding wait states when they wouldn't otherwise be necessary.
2026-06-17 Add SwInt test cases.
2026-06-17 Add board / pld rev test cases.
2026-06-17 Add UART I/O test cases.
2026-06-17 ATA bus cycle tests.
2026-06-17 Remove unnecessary check.
2026-06-17 Fix some silliness around interrupt enables that was actually due to a testbench bug. Add another introspection hook into the timer for the testbench.
2026-06-17 Generate the memctl JEDEC.
2026-06-17 Rename the ADDR pins; previously was confusing the fitter.
2026-06-17 Rename ADDR pins to avoid confusing the fitter.
2026-06-17 Define some more common nodes.
2026-06-18 Roll back.
2026-06-18 Re-add the board / PLD revision registers.
2026-06-18 re-apply IPL -> nIPL
2026-06-18 Re-apply the "rename ADDR pins to keep the fitter from getting confused".
2026-06-18 Set /AVEC combinatorially.
2026-06-18 Invert the sense of DevSelects.
2026-06-18 FAST_DTACK for 16-bit ATA.
2026-06-18 Fast DTACK for the UART, too.
2026-06-18 Re-add Timer test hooks.
2026-06-18 Once again fix the 8-bit ATA timings. It fits!
2026-06-18 Oops, fix the state variable width.
2026-06-18 Re-introduce the /AS qualificaiton for space decoding.
2026-06-18 Initial gen of JTAG files.
2026-06-18 Update cpu010 timer driver for recent changes.
2026-06-18 ATA is now 16-bit by default.
2026-06-18 vme -> nqvme
2026-06-18 Remove some files I was experimenting with, but no longer need.
2026-06-19 Re-factor the 7seg display character values so asm code can use them.
2026-06-19 Fix bad shift.
2026-06-19 Make sure the chars all fit in 8 bits.
2026-06-19 Oops, missing octothorpe.
2026-06-20 Document reset circuit errata and the work-around.
2026-06-20 Fix Errata A.2 -- Buffer the PWR_OK output to the LED and the DS1813 with a new N-FET / P-FET high-side switch controlled by PWR_OK from the PSU.
2026-06-20 Oops, fix swapped source/drain on Q802.
2026-06-21 OpenOCD specfies devices starting at nearest-TDO, whereas ATMISP specifies them starting at nearest-TDI.
2026-06-21 First pass at an S-record loader.
2026-06-22 Add an "srec" command for loading S-Records. Not terribly useful yet -- bootinfo with S-Records is a challenge.
2026-06-24 Print the partition scheme before the table.
2026-06-25 - Add support for writing. - Must wait-for-DRQ for reads, too.
2026-06-25 Use twiddle().
2026-06-30 Add a tool, "rompad", that pads the ROM image to the next power-of-2 size and then repeats that image as many times as necessary to fit into the specified ROM image size.
2026-06-30 Link the rom at 0x00fe0000, running it from the top 128K of the address space.
2026-06-30 Oops, don't forget the SegMap entries for the reserved RAM region!
2026-06-30 Put OBIO space just below reserved RAM. All told, this frees up quite a bit of VA space for he OS kernek.
