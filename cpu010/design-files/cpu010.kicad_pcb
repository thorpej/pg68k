File: cpu010/design-files/cpu010.kicad_pcb (KiCad board)
At the start: 2 copper layers, 370.8 x 223.5 mm, 60 parts, among them SW201 Reset, SW401 SW_DIP_x08, SW402 SW_DIP_x08, U101 GAL22V10, U201 MC68010P, U202 74ACT163, U203 74ACT05, U204 DS1813, U301 ATF1508AS-TQFP100, U302 61C3216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

Commit message: Some decoupling caps.
Parts:
- added C101: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (236.2, 166.9)
- added C202: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (42.9, 144.8)
- added C203: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (68.6, 83.1)
- added C204: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (41.6, 99.1)
- added C205: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (111.8, 154.2)
- added C301: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (88.9, 100.8)
- added C302: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (88.9, 131.3)
- added C303: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (134.6, 100.8)
- added C304: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (134.7, 131.3)
- added C305: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (134.7, 161.8)
- added C401: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (88.9, 169.4)
- added C402: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (83.8, 212.6)
- added C403: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (109.2, 212.6)
- added C404: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (137.2, 212.6)
- added C405: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (154.9, 212.6)
- added C406: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (152.4, 172.0)
- added C407: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, F.Cu at (167.6, 172.0)
- moved Y201 1.36 mm to (45.7, 99.1)
- moved U407 1.02 mm to (160.0, 175.3)
- moved U408 1.02 mm to (144.8, 175.3)

Commit message: Need a pull-up on /RESET!
Parts:
- added R205: 3K3, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, F.Cu at (73.7, 203.2)
- moved C201 1.52 mm to (54.4, 203.2)
- moved U204 1.52 mm to (59.4, 203.2)
Changed lines of the file:
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@@
 	(footprint "Capacitor_THT:CP_Radial_D6.3mm_P2.50mm"
 		(layer "F.Cu")
-		(at 55.88 203.2 180)
+		(at 54.356 203.2 180)
 		(descr "CP, Radial series, Radial, pin pitch=2.50mm, diameter=6.3mm, height=7mm, Electrolytic Capacitor")
 		(tags "CP Radial series Radial pin pitch 2.50mm diameter 6.3mm height 7mm Electrolytic Capacitor")
@@
 		)
 	)
+	(footprint "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal"
+		(layer "F.Cu")
+		(at 73.66 203.2 180)
+		(descr "Resistor, Axial_DIN0207 series, Axial, Horizontal, pin pitch=7.62mm, 0.25W = 1/4W, length*diameter=6.3*2.5mm^2, http://cdn-reichelt.de/documents/datenblatt/B400/1_4W%23YAG.pdf")
+		(tags "Resistor Axial_DIN0207 series Axial Horizontal pin pitch 7.62mm 0.25W = 1/4W length 6.3mm diameter 2.5mm")
+		(property "Reference" "R205"
+			(at 3.81 -2.37 0)
+			(layer "F.SilkS")
+			(effects
+				(font
+					(size 1 1)
+					(thickness 0.15)
+				)
+			)
+		)
+		(property "Value" "3K3"
+			(at 3.81 2.37 0)
+			(layer "F.SilkS")
+			(effects
+				(font
+					(size 1 1)
+					(thickness 0.15)
+				)
+			)
+		)
+		(property "Datasheet" ""
+			(at 0 0 0)
+			(layer "F.Fab")
+			(hide yes)
+			(effects
+				(font
+					(size 1.27 1.27)
+					(thickness 0.15)
+				)
+			)
+		)
+		(property "Description" "Resistor, small symbol"
+			(at 0 0 0)
+			(layer "F.Fab")
+			(hide yes)
+			(effects
+				(font
+					(size 1.27 1.27)
+					(thickness 0.15)
+				)
+			)
+		)
+		(property ki_fp_filters "R_*")
+		(sheetname "/CPU/")
+		(sheetfile "cpu010-cpu.kicad_sch")
+		(attr through_hole)
+		(fp_line
+			(start 7.08 1.37)
+			(end 7.08 1.04)
+			(stroke
+				(width 0.12)
+				(type solid)
+			)
+			(layer "F.SilkS")
+		)
+		(fp_line
+			(start 7.08 -1.37)
+			(end 7.08 -1.04)
+			(stroke
+				(width 0.12)
+				(type solid)
+			)
+			(layer "F.SilkS")
+		)
+		(fp_line
+			(start 0.54 1.37)
+			(end 7.08 1.37)
+			(stroke
+				(width 0.12)
+				(type solid)
+			)
+			(layer "F.SilkS")
+		)
+		(fp_line
+			(start 0.54 1.04)
+			(end 0.54 1.37)
+			(stroke
+				(width 0.12)
+				(type solid)
+			)
+			(layer "F.SilkS")
+		)
+		(fp_line
+			(start 0.54 -1.04)
+			(end 0.54 -1.37)
+			(stroke
+				(width 0.12)
+				(type solid)
+			)
+			(layer "F.SilkS")
+		)
+		(fp_line
+			(start 0.54 -1.37)
+			(end 7.08 -1.37)
+			(stroke
+				(width 0.12)
+				(type solid)
+			)
+			(layer "F.SilkS")
+		)
+		(fp_rect
+			(start -1.05 -1.5)
+			(end 8.67 1.5)
+			(stroke
+				(width 0.05)
+				(type solid)
+			)
+			(fill no)
+			(layer "F.CrtYd")
+		)
+		(fp_line
+			(start 7.62 0)
+			(end 6.96 0)
+			(stroke
+				(width 0.1)
+				(type solid)
+			)
+			(layer "F.Fab")
+		)
+		(fp_line
+			(start 0 0)
+			(end 0.66 0)
+			(stroke
+				(width 0.1)
+				(type solid)
+			)
+			(layer "F.Fab")
+		)
+		(fp_rect
+			(start 0.66 -1.25)
+			(end 6.96 1.25)
+			(stroke
+				(width 0.1)
+				(type solid)
+			)
+			(fill no)
+			(layer "F.Fab")
+		)
+		(fp_text user "${REFERENCE}"
+			(at 3.81 0 0)
+			(layer "F.Fab")
+			(effects
+				(font
+					(size 1 1)
+					(thickness 0.15)
+				)
+			)
+		)
+		(pad "1" thru_hole circle
+			(at 0 0 180)
+			(size 1.6 1.6)
+			(drill 0.8)
+			(layers "*.Cu" "*.Mask")
+			(remove_unused_layers no)
+			(net 243 "~{RESET}")
+			(pintype "passive")
+		)
+		(pad "2" thru_hole circle
+			(at 7.62 0 180)
+			(size 1.6 1.6)
+			(drill 0.8)
+			(layers "*.Cu" "*.Mask")
+			(remove_unused_layers no)
+			(net 18 "+5V")
+			(pintype "passive")
+		)
+		(embedded_fonts no)
+		(model "${KICAD9_3DMODEL_DIR}/Resistor_THT.3dshapes/R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal.step"
+			(offset
+				(xyz 0 0 0)
+			)
+			(scale
+				(xyz 1 1 1)
+			)
+			(rotate
+				(xyz 0 0 0)
+			)
+		)
+	)
 	(footprint "Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm"
 		(layer "F.Cu")
@@
 	(footprint "Package_TO_SOT_THT:TO-92_Inline"
 		(layer "F.Cu")
-		(at 60.96 203.2)
+		(at 59.436 203.2)
 		(descr "TO-92 leads in-line, narrow, oval pads, drill 0.75mm (see NXP sot054_po.pdf)")
 		(tags "to-92 sc-43 sc-43a sot54 PA33 transistor")
@@
 		)
 	)
-	(gr_text "Board Control Space Decoding"
-		(at 73.66 205.74 0)
+	(gr_text "Board Control\nSpace Decoding"
+		(at 85.09 207.01 0)
 		(layer "F.SilkS")
 		(effects
@@
 				(italic yes)
 			)
-			(justify left bottom)
+			(justify bottom)
 		)
 	)

Commit message: SMT 0805 bypass caps everywere.
Parts:
- added C306: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (155.2, 105.2)
- added C307: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (155.2, 135.6)
- added C308: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (170.4, 105.2)
- added C309: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (170.4, 135.6)
- added C310: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (188.2, 105.2)
- added C311: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (188.2, 130.6)
- added C312: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (188.2, 156.0)
- added C313: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (188.2, 181.4)
- added C314: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (203.5, 181.4)
- added C315: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (223.5, 105.2)
- added C316: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (223.5, 130.6)
- added C317: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (223.5, 156.0)
- added C318: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (223.5, 181.4)
- added C319: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (241.3, 105.2)
- added C320: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (241.3, 135.6)
- added C321: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (191.0, 120.1)
- added C322: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (207.5, 121.4)
- added C323: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (191.0, 154.9)
- added C324: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (207.5, 156.2)
- added C325: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (98.6, 102.6)
- added C326: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (98.6, 110.3)
- added C327: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (107.2, 118.1)
- added C328: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (119.9, 113.8)
- added C329: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (119.9, 106.2)
- added C330: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (112.3, 95.2)
- added C331: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (107.7, 95.2)
- added C332: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (109.7, 118.1)
- added C333: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (99.4, 136.7)
- added C334: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (116.2, 137.9)
- added C408: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (94.5, 195.3)
- added C409: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (121.4, 190.2)
- added C410: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (94.5, 199.4)
- added C411: 220nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (94.5, 184.2)
- added C501: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (241.3, 211.8)
- added C502: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (266.7, 135.6)
- added C503: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (288.3, 135.6)
- added C504: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (246.4, 196.1)
- added C505: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (264.2, 196.8)
- added C506: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (266.2, 196.1)
- added C507: 100nF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (284.0, 196.8)
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Connections:
- RN401 pad 8: Net-(RN401-R8.1) -> unconnected-(RN401-R8.1-Pad8)
- RN401 pad 9: unconnected-(RN401-R8.2-Pad9) -> Net-(RN401-R8.2)
- RN402 pad 8: Net-(RN402-R8.1) -> unconnected-(RN402-R8.1-Pad8)
- RN402 pad 9: unconnected-(RN402-R8.2-Pad9) -> Net-(RN402-R8.2)
- U401 pad 1: Net-(RN401-R3.2) -> Net-(RN401-R3.1)
- U401 pad 10: Net-(RN402-R1.2) -> Net-(RN402-R1.1)
- U401 pad 11: Net-(RN402-R6.2) -> Net-(RN402-R6.1)
- U401 pad 12: Net-(RN402-R2.2) -> Net-(RN402-R2.1)
- U401 pad 13: Net-(RN401-R2.2) -> Net-(RN401-R2.1)
- U401 pad 14: Net-(RN401-R6.2) -> Net-(RN401-R6.1)
- U401 pad 15: Net-(RN401-R1.2) -> Net-(RN401-R1.1)
- U401 pad 16: Net-(RN401-R7.2) -> Net-(RN401-R7.1)
- U401 pad 2: Net-(RN401-R5.2) -> Net-(RN401-R5.1)
- U401 pad 3: Net-(RN401-R4.2) -> Net-(RN401-R4.1)
- U401 pad 6: Net-(RN402-R4.2) -> Net-(RN402-R4.1)
- U401 pad 7: Net-(RN402-R5.2) -> Net-(RN402-R5.1)
- U401 pad 8: Net-(RN402-R3.2) -> Net-(RN402-R3.1)
- U401 pad 9: Net-(RN402-R7.2) -> Net-(RN402-R7.1)
- U402 pad 12: Net-(RN401-R5.1) -> Net-(RN401-R5.2)
- U402 pad 15: Net-(RN401-R6.1) -> Net-(RN401-R6.2)
- U402 pad 16: Net-(RN401-R7.1) -> Net-(RN401-R7.2)
- U402 pad 19: Net-(RN401-R8.1) -> Net-(RN401-R8.2)
- U402 pad 2: Net-(RN401-R1.1) -> Net-(RN401-R1.2)
- U402 pad 5: Net-(RN401-R2.1) -> Net-(RN401-R2.2)
- U402 pad 6: Net-(RN401-R3.1) -> Net-(RN401-R3.2)
- U402 pad 9: Net-(RN401-R4.1) -> Net-(RN401-R4.2)
- U403 pad 12: Net-(RN402-R5.1) -> Net-(RN402-R5.2)
- U403 pad 15: Net-(RN402-R6.1) -> Net-(RN402-R6.2)
- U403 pad 16: Net-(RN402-R7.1) -> Net-(RN402-R7.2)
- U403 pad 19: Net-(RN402-R8.1) -> Net-(RN402-R8.2)
- U403 pad 2: Net-(RN402-R1.1) -> Net-(RN402-R1.2)
- U403 pad 5: Net-(RN402-R2.1) -> Net-(RN402-R2.2)
- U403 pad 6: Net-(RN402-R3.1) -> Net-(RN402-R3.2)
- U403 pad 9: Net-(RN402-R4.1) -> Net-(RN402-R4.2)
